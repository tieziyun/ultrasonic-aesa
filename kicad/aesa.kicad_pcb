# Repository tieziyun/ultrasonic-aesa (continued)

## KiCad design kicad/aesa.kicad_pcb (continued)

Schematic: channel.kicad_sch, Transceiver channel (x64): TX, T/R switch, RX amplifier

Parts:
C101, C102, C103: 100n 16V X7R; C_0603_1608Metric; LCSC C14663
C104, C105: 1n 50V C0G 1%; C_0603_1608Metric; LCSC C309468
C106: 100p 50V C0G; C_0603_1608Metric; LCSC C14858
C107: 33p 50V C0G; C_0603_1608Metric; LCSC C1663
D101, D102: BAV99; SOT-23; LCSC C2500
LS101: CUSP-TR80-15-2500-TH; CUSP-TR80; LCSC hand-solder; not fitted
R101: 47 1%; R_0603_1608Metric; LCSC C23182
R102: 33k 1%; R_0603_1608Metric; LCSC C4216
R103: 4.7k 1%; R_0603_1608Metric; LCSC C23162
R104: 10k 1%; R_0603_1608Metric; LCSC C25804
R105, R106, R107: 2k 1%; R_0603_1608Metric; LCSC C22975
R108: 16k 1%; R_0603_1608Metric; LCSC C4210
R109: 100 1%; R_0603_1608Metric; LCSC C22775
TP101: RX; TestPoint_Pad_D1.0mm; LCSC none (copper)
U101: OPA1678IDR; SOIC-8_3.9x4.9mm_P1.27mm; LCSC C192421

Connections:
+5VA: C101.1, U101.8 (V+); also elsewhere on the board
-5VA: C102.2, U101.4 (V-); also elsewhere on the board
/Transceivers/CH01/DRV: D101.1 (K), D101.2 (A), R101.2
/Transceivers/CH01/FB1: C107.1, R104.1, R105.1, U101.6 (-)
/Transceivers/CH01/INV2: C104.2, R108.1, U101.2 (-)
/Transceivers/CH01/LIM: C106.2, D102.3 (K), R103.2, U101.5 (+)
/Transceivers/CH01/N2: C104.1, C105.1, R106.2, R107.1
/Transceivers/CH01/OUT2: C105.2, R108.2, R109.1, U101.1
/Transceivers/CH01/S1: C107.2, R104.2, R106.1, U101.7
/Transceivers/CH01/XD: D101.3 (K), LS101.1, R102.1, R103.1
DRV1: R101.1; also elsewhere on the board
GND: C101.2, C102.1, C103.2, C106.1, D102.1 (K), D102.2 (A), LS101.2, R102.2, R107.2, U101.3 (+); also elsewhere on the board
unnamed: C103.1, R105.2
RX1: R109.2, TP101.1; also elsewhere on the board

Parts of its further copies:
C201, C202, C203, C301, C302, C303, C401, C402, C403, C501, C502, C503, C601, C602, C603, C701, C702, C703, C801, C802, C803, C901, C902, C903, C1001, C1002, C1003, C1101, C1102, C1103, C1201, C1202, C1203, C1301, C1302, C1303, C1401, C1402, C1403, C1501, C1502, C1503, C1601, C1602, C1603, C1701, C1702, C1703, C1801, C1802, C1803, C1901, C1902, C1903, C2001, C2002, C2003, C2101, C2102, C2103, C2201, C2202, C2203, C2301, C2302, C2303, C2401, C2402, C2403, C2501, C2502, C2503, C2601, C2602, C2603, C2701, C2702, C2703, C2801, C2802, C2803, C2901, C2902, C2903, C3001, C3002, C3003, C3101, C3102, C3103, C3201, C3202, C3203, C3301, C3302, C3303, C3401, C3402, C3403, C3501, C3502, C3503, C3601, C3602, C3603, C3701, C3702, C3703, C3801, C3802, C3803, C3901, C3902, C3903, C4001, C4002, C4003, C4101, C4102, C4103, C4201, C4202, C4203, C4301, C4302, C4303, C4401, C4402, C4403, C4501, C4502, C4503, C4601, C4602, C4603, C4701, C4702, C4703, C4801, C4802, C4803, C4901, C4902, C4903, C5001, C5002, C5003, C5101, C5102, C5103, C5201, C5202, C5203, C5301, C5302, C5303, C5401, C5402, C5403, C5501, C5502, C5503, C5601, C5602, C5603, C5701, C5702, C5703, C5801, C5802, C5803, C5901, C5902, C5903, C6001, C6002, C6003, C6101, C6102, C6103, C6201, C6202, C6203, C6301, C6302, C6303, C6401, C6402, C6403: 100n 16V X7R; C_0603_1608Metric; LCSC C14663
C204, C205, C304, C305, C404, C405, C504, C505, C604, C605, C704, C705, C804, C805, C904, C905, C1004, C1005, C1104, C1105, C1204, C1205, C1304, C1305, C1404, C1405, C1504, C1505, C1604, C1605, C1704, C1705, C1804, C1805, C1904, C1905, C2004, C2005, C2104, C2105, C2204, C2205, C2304, C2305, C2404, C2405, C2504, C2505, C2604, C2605, C2704, C2705, C2804, C2805, C2904, C2905, C3004, C3005, C3104, C3105, C3204, C3205, C3304, C3305, C3404, C3405, C3504, C3505, C3604, C3605, C3704, C3705, C3804, C3805, C3904, C3905, C4004, C4005, C4104, C4105, C4204, C4205, C4304, C4305, C4404, C4405, C4504, C4505, C4604, C4605, C4704, C4705, C4804, C4805, C4904, C4905, C5004, C5005, C5104, C5105, C5204, C5205, C5304, C5305, C5404, C5405, C5504, C5505, C5604, C5605, C5704, C5705, C5804, C5805, C5904, C5905, C6004, C6005, C6104, C6105, C6204, C6205, C6304, C6305, C6404, C6405: 1n 50V C0G 1%; C_0603_1608Metric; LCSC C309468
C206, C306, C406, C506, C606, C706, C806, C906, C1006, C1106, C1206, C1306, C1406, C1506, C1606, C1706, C1806, C1906, C2006, C2106, C2206, C2306, C2406, C2506, C2606, C2706, C2806, C2906, C3006, C3106, C3206, C3306, C3406, C3506, C3606, C3706, C3806, C3906, C4006, C4106, C4206, C4306, C4406, C4506, C4606, C4706, C4806, C4906, C5006, C5106, C5206, C5306, C5406, C5506, C5606, C5706, C5806, C5906, C6006, C6106, C6206, C6306, C6406: 100p 50V C0G; C_0603_1608Metric; LCSC C14858
C207, C307, C407, C507, C607, C707, C807, C907, C1007, C1107, C1207, C1307, C1407, C1507, C1607, C1707, C1807, C1907, C2007, C2107, C2207, C2307, C2407, C2507, C2607, C2707, C2807, C2907, C3007, C3107, C3207, C3307, C3407, C3507, C3607, C3707, C3807, C3907, C4007, C4107, C4207, C4307, C4407, C4507, C4607, C4707, C4807, C4907, C5007, C5107, C5207, C5307, C5407, C5507, C5607, C5707, C5807, C5907, C6007, C6107, C6207, C6307, C6407: 33p 50V C0G; C_0603_1608Metric; LCSC C1663
D201, D202, D301, D302, D401, D402, D501, D502, D601, D602, D701, D702, D801, D802, D901, D902, D1001, D1002, D1101, D1102, D1201, D1202, D1301, D1302, D1401, D1402, D1501, D1502, D1601, D1602, D1701, D1702, D1801, D1802, D1901, D1902, D2001, D2002, D2101, D2102, D2201, D2202, D2301, D2302, D2401, D2402, D2501, D2502, D2601, D2602, D2701, D2702, D2801, D2802, D2901, D2902, D3001, D3002, D3101, D3102, D3201, D3202, D3301, D3302, D3401, D3402, D3501, D3502, D3601, D3602, D3701, D3702, D3801, D3802, D3901, D3902, D4001, D4002, D4101, D4102, D4201, D4202, D4301, D4302, D4401, D4402, D4501, D4502, D4601, D4602, D4701, D4702, D4801, D4802, D4901, D4902, D5001, D5002, D5101, D5102, D5201, D5202, D5301, D5302, D5401, D5402, D5501, D5502, D5601, D5602, D5701, D5702, D5801, D5802, D5901, D5902, D6001, D6002, D6101, D6102, D6201, D6202, D6301, D6302, D6401, D6402: BAV99; SOT-23; LCSC C2500
LS201, LS301, LS401, LS501, LS601, LS701, LS801, LS901, LS1001, LS1101, LS1201, LS1301, LS1401, LS1501, LS1601, LS1701, LS1801, LS1901, LS2001, LS2101, LS2201, LS2301, LS2401, LS2501, LS2601, LS2701, LS2801, LS2901, LS3001, LS3101, LS3201, LS3301, LS3401, LS3501, LS3601, LS3701, LS3801, LS3901, LS4001, LS4101, LS4201, LS4301, LS4401, LS4501, LS4601, LS4701, LS4801, LS4901, LS5001, LS5101, LS5201, LS5301, LS5401, LS5501, LS5601, LS5701, LS5801, LS5901, LS6001, LS6101, LS6201, LS6301, LS6401: CUSP-TR80-15-2500-TH; CUSP-TR80; LCSC hand-solder; not fitted
R201, R301, R401, R501, R601, R701, R801, R901, R1001, R1101, R1201, R1301, R1401, R1501, R1601, R1701, R1801, R1901, R2001, R2101, R2201, R2301, R2401, R2501, R2601, R2701, R2801, R2901, R3001, R3101, R3201, R3301, R3401, R3501, R3601, R3701, R3801, R3901, R4001, R4101, R4201, R4301, R4401, R4501, R4601, R4701, R4801, R4901, R5001, R5101, R5201, R5301, R5401, R5501, R5601, R5701, R5801, R5901, R6001, R6101, R6201, R6301, R6401: 47 1%; R_0603_1608Metric; LCSC C23182
R202, R302, R402, R502, R602, R702, R802, R902, R1002, R1102, R1202, R1302, R1402, R1502, R1602, R1702, R1802, R1902, R2002, R2102, R2202, R2302, R2402, R2502, R2602, R2702, R2802, R2902, R3002, R3102, R3202, R3302, R3402, R3502, R3602, R3702, R3802, R3902, R4002, R4102, R4202, R4302, R4402, R4502, R4602, R4702, R4802, R4902, R5002, R5102, R5202, R5302, R5402, R5502, R5602, R5702, R5802, R5902, R6002, R6102, R6202, R6302, R6402: 33k 1%; R_0603_1608Metric; LCSC C4216
R203, R303, R403, R503, R603, R703, R803, R903, R1003, R1103, R1203, R1303, R1403, R1503, R1603, R1703, R1803, R1903, R2003, R2103, R2203, R2303, R2403, R2503, R2603, R2703, R2803, R2903, R3003, R3103, R3203, R3303, R3403, R3503, R3603, R3703, R3803, R3903, R4003, R4103, R4203, R4303, R4403, R4503, R4603, R4703, R4803, R4903, R5003, R5103, R5203, R5303, R5403, R5503, R5603, R5703, R5803, R5903, R6003, R6103, R6203, R6303, R6403: 4.7k 1%; R_0603_1608Metric; LCSC C23162
R204, R304, R404, R504, R604, R704, R804, R904, R1004, R1104, R1204, R1304, R1404, R1504, R1604, R1704, R1804, R1904, R2004, R2104, R2204, R2304, R2404, R2504, R2604, R2704, R2804, R2904, R3004, R3104, R3204, R3304, R3404, R3504, R3604, R3704, R3804, R3904, R4004, R4104, R4204, R4304, R4404, R4504, R4604, R4704, R4804, R4904, R5004, R5104, R5204, R5304, R5404, R5504, R5604, R5704, R5804, R5904, R6004, R6104, R6204, R6304, R6404: 10k 1%; R_0603_1608Metric; LCSC C25804
R205, R206, R207, R305, R306, R307, R405, R406, R407, R505, R506, R507, R605, R606, R607, R705, R706, R707, R805, R806, R807, R905, R906, R907, R1005, R1006, R1007, R1105, R1106, R1107, R1205, R1206, R1207, R1305, R1306, R1307, R1405, R1406, R1407, R1505, R1506, R1507, R1605, R1606, R1607, R1705, R1706, R1707, R1805, R1806, R1807, R1905, R1906, R1907, R2005, R2006, R2007, R2105, R2106, R2107, R2205, R2206, R2207, R2305, R2306, R2307, R2405, R2406, R2407, R2505, R2506, R2507, R2605, R2606, R2607, R2705, R2706, R2707, R2805, R2806, R2807, R2905, R2906, R2907, R3005, R3006, R3007, R3105, R3106, R3107, R3205, R3206, R3207, R3305, R3306, R3307, R3405, R3406, R3407, R3505, R3506, R3507, R3605, R3606, R3607, R3705, R3706, R3707, R3805, R3806, R3807, R3905, R3906, R3907, R4005, R4006, R4007, R4105, R4106, R4107, R4205, R4206, R4207, R4305, R4306, R4307, R4405, R4406, R4407, R4505, R4506, R4507, R4605, R4606, R4607, R4705, R4706, R4707, R4805, R4806, R4807, R4905, R4906, R4907, R5005, R5006, R5007, R5105, R5106, R5107, R5205, R5206, R5207, R5305, R5306, R5307, R5405, R5406, R5407, R5505, R5506, R5507, R5605, R5606, R5607, R5705, R5706, R5707, R5805, R5806, R5807, R5905, R5906, R5907, R6005, R6006, R6007, R6105, R6106, R6107, R6205, R6206, R6207, R6305, R6306, R6307, R6405, R6406, R6407: 2k 1%; R_0603_1608Metric; LCSC C22975
R208, R308, R408, R508, R608, R708, R808, R908, R1008, R1108, R1208, R1308, R1408, R1508, R1608, R1708, R1808, R1908, R2008, R2108, R2208, R2308, R2408, R2508, R2608, R2708, R2808, R2908, R3008, R3108, R3208, R3308, R3408, R3508, R3608, R3708, R3808, R3908, R4008, R4108, R4208, R4308, R4408, R4508, R4608, R4708, R4808, R4908, R5008, R5108, R5208, R5308, R5408, R5508, R5608, R5708, R5808, R5908, R6008, R6108, R6208, R6308, R6408: 16k 1%; R_0603_1608Metric; LCSC C4210
R209, R309, R409, R509, R609, R709, R809, R909, R1009, R1109, R1209, R1309, R1409, R1509, R1609, R1709, R1809, R1909, R2009, R2109, R2209, R2309, R2409, R2509, R2609, R2709, R2809, R2909, R3009, R3109, R3209, R3309, R3409, R3509, R3609, R3709, R3809, R3909, R4009, R4109, R4209, R4309, R4409, R4509, R4609, R4709, R4809, R4909, R5009, R5109, R5209, R5309, R5409, R5509, R5609, R5709, R5809, R5909, R6009, R6109, R6209, R6309, R6409: 100 1%; R_0603_1608Metric; LCSC C22775
TP201, TP301, TP401, TP501, TP601, TP701, TP801, TP901, TP1001, TP1101, TP1201, TP1301, TP1401, TP1501, TP1601, TP1701, TP1801, TP1901, TP2001, TP2101, TP2201, TP2301, TP2401, TP2501, TP2601, TP2701, TP2801, TP2901, TP3001, TP3101, TP3201, TP3301, TP3401, TP3501, TP3601, TP3701, TP3801, TP3901, TP4001, TP4101, TP4201, TP4301, TP4401, TP4501, TP4601, TP4701, TP4801, TP4901, TP5001, TP5101, TP5201, TP5301, TP5401, TP5501, TP5601, TP5701, TP5801, TP5901, TP6001, TP6101, TP6201, TP6301, TP6401: RX; TestPoint_Pad_D1.0mm; LCSC none (copper)
U201, U301, U401, U501, U601, U701, U801, U901, U1001, U1101, U1201, U1301, U1401, U1501, U1601, U1701, U1801, U1901, U2001, U2101, U2201, U2301, U2401, U2501, U2601, U2701, U2801, U2901, U3001, U3101, U3201, U3301, U3401, U3501, U3601, U3701, U3801, U3901, U4001, U4101, U4201, U4301, U4401, U4501, U4601, U4701, U4801, U4901, U5001, U5101, U5201, U5301, U5401, U5501, U5601, U5701, U5801, U5901, U6001, U6101, U6201, U6301, U6401: OPA1678IDR; SOIC-8_3.9x4.9mm_P1.27mm; LCSC C192421

Connections of its further copies (part):
+5VA: C201.1, C301.1, C401.1, C501.1, C601.1, C701.1, C801.1, C901.1, C1001.1, C1101.1, C1201.1, C1301.1, C1401.1, C1501.1, C1601.1, C1701.1, C1801.1, C1901.1, C2001.1, C2101.1, C2201.1, C2301.1, C2401.1, C2501.1, C2601.1, C2701.1, C2801.1, C2901.1, C3001.1, C3101.1, C3201.1, C3301.1, C3401.1, C3501.1, C3601.1, C3701.1, C3801.1, C3901.1, C4001.1, C4101.1, C4201.1, C4301.1, C4401.1, C4501.1, C4601.1, C4701.1, C4801.1, C4901.1, C5001.1, C5101.1, C5201.1, C5301.1, C5401.1, C5501.1, C5601.1, C5701.1, C5801.1, C5901.1, C6001.1, C6101.1, C6201.1, C6301.1, C6401.1, U201.8 (V+), U301.8 (V+), U401.8 (V+), U501.8 (V+), U601.8 (V+), U701.8 (V+), U801.8 (V+), U901.8 (V+), U1001.8 (V+), U1101.8 (V+), U1201.8 (V+), U1301.8 (V+), U1401.8 (V+), U1501.8 (V+), U1601.8 (V+), U1701.8 (V+), U1801.8 (V+), U1901.8 (V+), U2001.8 (V+), U2101.8 (V+), U2201.8 (V+), U2301.8 (V+), U2401.8 (V+), U2501.8 (V+), U2601.8 (V+), U2701.8 (V+)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; also elsewhere on the board
-5VA: C202.2, C302.2, C402.2, C502.2, C602.2, C702.2, C802.2, C902.2, C1002.2, C1102.2, C1202.2, C1302.2, C1402.2, C1502.2, C1602.2, C1702.2, C1802.2, C1902.2, C2002.2, C2102.2, C2202.2, C2302.2, C2402.2, C2502.2, C2602.2, C2702.2, C2802.2, C2902.2, C3002.2, C3102.2, C3202.2, C3302.2, C3402.2, C3502.2, C3602.2, C3702.2, C3802.2, C3902.2, C4002.2, C4102.2, C4202.2, C4302.2, C4402.2, C4502.2, C4602.2, C4702.2, C4802.2, C4902.2, C5002.2, C5102.2, C5202.2, C5302.2, C5402.2, C5502.2, C5602.2, C5702.2, C5802.2, C5902.2, C6002.2, C6102.2, C6202.2, C6302.2, C6402.2, U201.4 (V-), U301.4 (V-), U401.4 (V-), U501.4 (V-), U601.4 (V-), U701.4 (V-), U801.4 (V-), U901.4 (V-), U1001.4 (V-), U1101.4 (V-), U1201.4 (V-), U1301.4 (V-), U1401.4 (V-), U1501.4 (V-), U1601.4 (V-), U1701.4 (V-), U1801.4 (V-), U1901.4 (V-), U2001.4 (V-), U2101.4 (V-), U2201.4 (V-), U2301.4 (V-), U2401.4 (V-), U2501.4 (V-), U2601.4 (V-), U2701.4 (V-)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; also elsewhere on the board
/Transceivers/CH02/DRV: D201.1 (K), D201.2 (A), R201.2
/Transceivers/CH02/FB1: C207.1, R204.1, R205.1, U201.6 (-)
/Transceivers/CH02/INV2: C204.2, R208.1, U201.2 (-)
/Transceivers/CH02/LIM: C206.2, D202.3 (K), R203.2, U201.5 (+)
/Transceivers/CH02/N2: C204.1, C205.1, R206.2, R207.1
/Transceivers/CH02/OUT2: C205.2, R208.2, R209.1, U201.1
/Transceivers/CH02/S1: C207.2, R204.2, R206.1, U201.7
/Transceivers/CH02/XD: D201.3 (K), LS201.1, R202.1, R203.1
/Transceivers/CH03/DRV: D301.1 (K), D301.2 (A), R301.2
/Transceivers/CH03/FB1: C307.1, R304.1, R305.1, U301.6 (-)
/Transceivers/CH03/INV2: C304.2, R308.1, U301.2 (-)
/Transceivers/CH03/LIM: C306.2, D302.3 (K), R303.2, U301.5 (+)
/Transceivers/CH03/N2: C304.1, C305.1, R306.2, R307.1
/Transceivers/CH03/OUT2: C305.2, R308.2, R309.1, U301.1
/Transceivers/CH03/S1: C307.2, R304.2, R306.1, U301.7
/Transceivers/CH03/XD: D301.3 (K), LS301.1, R302.1, R303.1
/Transceivers/CH04/DRV: D401.1 (K), D401.2 (A), R401.2
/Transceivers/CH04/FB1: C407.1, R404.1, R405.1, U401.6 (-)
/Transceivers/CH04/INV2: C404.2, R408.1, U401.2 (-)
/Transceivers/CH04/LIM: C406.2, D402.3 (K), R403.2, U401.5 (+)
/Transceivers/CH04/N2: C404.1, C405.1, R406.2, R407.1
/Transceivers/CH04/OUT2: C405.2, R408.2, R409.1, U401.1
/Transceivers/CH04/S1: C407.2, R404.2, R406.1, U401.7
/Transceivers/CH04/XD: D401.3 (K), LS401.1, R402.1, R403.1
/Transceivers/CH05/DRV: D501.1 (K), D501.2 (A), R501.2
/Transceivers/CH05/FB1: C507.1, R504.1, R505.1, U501.6 (-)
/Transceivers/CH05/INV2: C504.2, R508.1, U501.2 (-)
/Transceivers/CH05/LIM: C506.2, D502.3 (K), R503.2, U501.5 (+)
/Transceivers/CH05/N2: C504.1, C505.1, R506.2, R507.1
/Transceivers/CH05/OUT2: C505.2, R508.2, R509.1, U501.1
/Transceivers/CH05/S1: C507.2, R504.2, R506.1, U501.7
/Transceivers/CH05/XD: D501.3 (K), LS501.1, R502.1, R503.1
/Transceivers/CH06/DRV: D601.1 (K), D601.2 (A), R601.2
/Transceivers/CH06/FB1: C607.1, R604.1, R605.1, U601.6 (-)
/Transceivers/CH06/INV2: C604.2, R608.1, U601.2 (-)
/Transceivers/CH06/LIM: C606.2, D602.3 (K), R603.2, U601.5 (+)
/Transceivers/CH06/N2: C604.1, C605.1, R606.2, R607.1
/Transceivers/CH06/OUT2: C605.2, R608.2, R609.1, U601.1
/Transceivers/CH06/S1: C607.2, R604.2, R606.1, U601.7
/Transceivers/CH06/XD: D601.3 (K), LS601.1, R602.1, R603.1
/Transceivers/CH07/DRV: D701.1 (K), D701.2 (A), R701.2
/Transceivers/CH07/FB1: C707.1, R704.1, R705.1, U701.6 (-)
/Transceivers/CH07/INV2: C704.2, R708.1, U701.2 (-)
/Transceivers/CH07/LIM: C706.2, D702.3 (K), R703.2, U701.5 (+)
/Transceivers/CH07/N2: C704.1, C705.1, R706.2, R707.1
/Transceivers/CH07/OUT2: C705.2, R708.2, R709.1, U701.1
/Transceivers/CH07/S1: C707.2, R704.2, R706.1, U701.7
/Transceivers/CH07/XD: D701.3 (K), LS701.1, R702.1, R703.1
/Transceivers/CH08/DRV: D801.1 (K), D801.2 (A), R801.2
/Transceivers/CH08/FB1: C807.1, R804.1, R805.1, U801.6 (-)
/Transceivers/CH08/INV2: C804.2, R808.1, U801.2 (-)
/Transceivers/CH08/LIM: C806.2, D802.3 (K), R803.2, U801.5 (+)
/Transceivers/CH08/N2: C804.1, C805.1, R806.2, R807.1
/Transceivers/CH08/OUT2: C805.2, R808.2, R809.1, U801.1
/Transceivers/CH08/S1: C807.2, R804.2, R806.1, U801.7
/Transceivers/CH08/XD: D801.3 (K), LS801.1, R802.1, R803.1
/Transceivers/CH09/DRV: D901.1 (K), D901.2 (A), R901.2
/Transceivers/CH09/FB1: C907.1, R904.1, R905.1, U901.6 (-)
/Transceivers/CH09/INV2: C904.2, R908.1, U901.2 (-)
/Transceivers/CH09/LIM: C906.2, D902.3 (K), R903.2, U901.5 (+)
/Transceivers/CH09/N2: C904.1, C905.1, R906.2, R907.1
/Transceivers/CH09/OUT2: C905.2, R908.2, R909.1, U901.1
/Transceivers/CH09/S1: C907.2, R904.2, R906.1, U901.7
/Transceivers/CH09/XD: D901.3 (K), LS901.1, R902.1, R903.1
/Transceivers/CH10/DRV: D1001.1 (K), D1001.2 (A), R1001.2
/Transceivers/CH10/FB1: C1007.1, R1004.1, R1005.1, U1001.6 (-)
/Transceivers/CH10/INV2: C1004.2, R1008.1, U1001.2 (-)
/Transceivers/CH10/LIM: C1006.2, D1002.3 (K), R1003.2, U1001.5 (+)
/Transceivers/CH10/N2: C1004.1, C1005.1, R1006.2, R1007.1
/Transceivers/CH10/OUT2: C1005.2, R1008.2, R1009.1, U1001.1
/Transceivers/CH10/S1: C1007.2, R1004.2, R1006.1, U1001.7
/Transceivers/CH10/XD: D1001.3 (K), LS1001.1, R1002.1, R1003.1
/Transceivers/CH11/DRV: D1101.1 (K), D1101.2 (A), R1101.2
/Transceivers/CH11/FB1: C1107.1, R1104.1, R1105.1, U1101.6 (-)
/Transceivers/CH11/INV2: C1104.2, R1108.1, U1101.2 (-)
/Transceivers/CH11/LIM: C1106.2, D1102.3 (K), R1103.2, U1101.5 (+)
/Transceivers/CH11/N2: C1104.1, C1105.1, R1106.2, R1107.1
/Transceivers/CH11/OUT2: C1105.2, R1108.2, R1109.1, U1101.1
/Transceivers/CH11/S1: C1107.2, R1104.2, R1106.1, U1101.7
/Transceivers/CH11/XD: D1101.3 (K), LS1101.1, R1102.1, R1103.1
/Transceivers/CH12/DRV: D1201.1 (K), D1201.2 (A), R1201.2
/Transceivers/CH12/FB1: C1207.1, R1204.1, R1205.1, U1201.6 (-)
/Transceivers/CH12/INV2: C1204.2, R1208.1, U1201.2 (-)
/Transceivers/CH12/LIM: C1206.2, D1202.3 (K), R1203.2, U1201.5 (+)
/Transceivers/CH12/N2: C1204.1, C1205.1, R1206.2, R1207.1
/Transceivers/CH12/OUT2: C1205.2, R1208.2, R1209.1, U1201.1
/Transceivers/CH12/S1: C1207.2, R1204.2, R1206.1, U1201.7
/Transceivers/CH12/XD: D1201.3 (K), LS1201.1, R1202.1, R1203.1
/Transceivers/CH13/DRV: D1301.1 (K), D1301.2 (A), R1301.2
/Transceivers/CH13/FB1: C1307.1, R1304.1, R1305.1, U1301.6 (-)
/Transceivers/CH13/INV2: C1304.2, R1308.1, U1301.2 (-)
/Transceivers/CH13/LIM: C1306.2, D1302.3 (K), R1303.2, U1301.5 (+)
/Transceivers/CH13/N2: C1304.1, C1305.1, R1306.2, R1307.1
/Transceivers/CH13/OUT2: C1305.2, R1308.2, R1309.1, U1301.1
/Transceivers/CH13/S1: C1307.2, R1304.2, R1306.1, U1301.7
/Transceivers/CH13/XD: D1301.3 (K), LS1301.1, R1302.1, R1303.1
/Transceivers/CH14/DRV: D1401.1 (K), D1401.2 (A), R1401.2
/Transceivers/CH14/FB1: C1407.1, R1404.1, R1405.1, U1401.6 (-)
/Transceivers/CH14/INV2: C1404.2, R1408.1, U1401.2 (-)
/Transceivers/CH14/LIM: C1406.2, D1402.3 (K), R1403.2, U1401.5 (+)
/Transceivers/CH14/N2: C1404.1, C1405.1, R1406.2, R1407.1
/Transceivers/CH14/OUT2: C1405.2, R1408.2, R1409.1, U1401.1
/Transceivers/CH14/S1: C1407.2, R1404.2, R1406.1, U1401.7
/Transceivers/CH14/XD: D1401.3 (K), LS1401.1, R1402.1, R1403.1
/Transceivers/CH15/DRV: D1501.1 (K), D1501.2 (A), R1501.2
/Transceivers/CH15/FB1: C1507.1, R1504.1, R1505.1, U1501.6 (-)
/Transceivers/CH15/INV2: C1504.2, R1508.1, U1501.2 (-)
/Transceivers/CH15/LIM: C1506.2, D1502.3 (K), R1503.2, U1501.5 (+)
/Transceivers/CH15/N2: C1504.1, C1505.1, R1506.2, R1507.1
/Transceivers/CH15/OUT2: C1505.2, R1508.2, R1509.1, U1501.1
/Transceivers/CH15/S1: C1507.2, R1504.2, R1506.1, U1501.7
/Transceivers/CH15/XD: D1501.3 (K), LS1501.1, R1502.1, R1503.1
/Transceivers/CH16/DRV: D1601.1 (K), D1601.2 (A), R1601.2
/Transceivers/CH16/FB1: C1607.1, R1604.1, R1605.1, U1601.6 (-)
/Transceivers/CH16/INV2: C1604.2, R1608.1, U1601.2 (-)
/Transceivers/CH16/LIM: C1606.2, D1602.3 (K), R1603.2, U1601.5 (+)
/Transceivers/CH16/N2: C1604.1, C1605.1, R1606.2, R1607.1
/Transceivers/CH16/OUT2: C1605.2, R1608.2, R1609.1, U1601.1
/Transceivers/CH16/S1: C1607.2, R1604.2, R1606.1, U1601.7
/Transceivers/CH16/XD: D1601.3 (K), LS1601.1, R1602.1, R1603.1
/Transceivers/CH17/DRV: D1701.1 (K), D1701.2 (A), R1701.2
/Transceivers/CH17/FB1: C1707.1, R1704.1, R1705.1, U1701.6 (-)
/Transceivers/CH17/INV2: C1704.2, R1708.1, U1701.2 (-)
/Transceivers/CH17/LIM: C1706.2, D1702.3 (K), R1703.2, U1701.5 (+)
/Transceivers/CH17/N2: C1704.1, C1705.1, R1706.2, R1707.1
/Transceivers/CH17/OUT2: C1705.2, R1708.2, R1709.1, U1701.1
/Transceivers/CH17/S1: C1707.2, R1704.2, R1706.1, U1701.7
/Transceivers/CH17/XD: D1701.3 (K), LS1701.1, R1702.1, R1703.1
/Transceivers/CH18/DRV: D1801.1 (K), D1801.2 (A), R1801.2
/Transceivers/CH18/FB1: C1807.1, R1804.1, R1805.1, U1801.6 (-)
/Transceivers/CH18/INV2: C1804.2, R1808.1, U1801.2 (-)
/Transceivers/CH18/LIM: C1806.2, D1802.3 (K), R1803.2, U1801.5 (+)
/Transceivers/CH18/N2: C1804.1, C1805.1, R1806.2, R1807.1
/Transceivers/CH18/OUT2: C1805.2, R1808.2, R1809.1, U1801.1
/Transceivers/CH18/S1: C1807.2, R1804.2, R1806.1, U1801.7
/Transceivers/CH18/XD: D1801.3 (K), LS1801.1, R1802.1, R1803.1
/Transceivers/CH19/DRV: D1901.1 (K), D1901.2 (A), R1901.2
/Transceivers/CH19/FB1: C1907.1, R1904.1, R1905.1, U1901.6 (-)
/Transceivers/CH19/INV2: C1904.2, R1908.1, U1901.2 (-)
/Transceivers/CH19/LIM: C1906.2, D1902.3 (K), R1903.2, U1901.5 (+)
/Transceivers/CH19/N2: C1904.1, C1905.1, R1906.2, R1907.1
/Transceivers/CH19/OUT2: C1905.2, R1908.2, R1909.1, U1901.1
/Transceivers/CH19/S1: C1907.2, R1904.2, R1906.1, U1901.7
/Transceivers/CH19/XD: D1901.3 (K), LS1901.1, R1902.1, R1903.1
/Transceivers/CH20/DRV: D2001.1 (K), D2001.2 (A), R2001.2
/Transceivers/CH20/FB1: C2007.1, R2004.1, R2005.1, U2001.6 (-)
/Transceivers/CH20/INV2: C2004.2, R2008.1, U2001.2 (-)
/Transceivers/CH20/LIM: C2006.2, D2002.3 (K), R2003.2, U2001.5 (+)
/Transceivers/CH20/N2: C2004.1, C2005.1, R2006.2, R2007.1
/Transceivers/CH20/OUT2: C2005.2, R2008.2, R2009.1, U2001.1
/Transceivers/CH20/S1: C2007.2, R2004.2, R2006.1, U2001.7
/Transceivers/CH20/XD: D2001.3 (K), LS2001.1, R2002.1, R2003.1
/Transceivers/CH21/DRV: D2101.1 (K), D2101.2 (A), R2101.2
/Transceivers/CH21/FB1: C2107.1, R2104.1, R2105.1, U2101.6 (-)
/Transceivers/CH21/INV2: C2104.2, R2108.1, U2101.2 (-)
/Transceivers/CH21/LIM: C2106.2, D2102.3 (K), R2103.2, U2101.5 (+)
/Transceivers/CH21/N2: C2104.1, C2105.1, R2106.2, R2107.1
/Transceivers/CH21/OUT2: C2105.2, R2108.2, R2109.1, U2101.1
/Transceivers/CH21/S1: C2107.2, R2104.2, R2106.1, U2101.7
/Transceivers/CH21/XD: D2101.3 (K), LS2101.1, R2102.1, R2103.1
/Transceivers/CH22/DRV: D2201.1 (K), D2201.2 (A), R2201.2
/Transceivers/CH22/FB1: C2207.1, R2204.1, R2205.1, U2201.6 (-)
/Transceivers/CH22/INV2: C2204.2, R2208.1, U2201.2 (-)
/Transceivers/CH22/LIM: C2206.2, D2202.3 (K), R2203.2, U2201.5 (+)
/Transceivers/CH22/N2: C2204.1, C2205.1, R2206.2, R2207.1
/Transceivers/CH22/OUT2: C2205.2, R2208.2, R2209.1, U2201.1
/Transceivers/CH22/S1: C2207.2, R2204.2, R2206.1, U2201.7
/Transceivers/CH22/XD: D2201.3 (K), LS2201.1, R2202.1, R2203.1
/Transceivers/CH23/DRV: D2301.1 (K), D2301.2 (A), R2301.2
/Transceivers/CH23/FB1: C2307.1, R2304.1, R2305.1, U2301.6 (-)
/Transceivers/CH23/INV2: C2304.2, R2308.1, U2301.2 (-)
/Transceivers/CH23/LIM: C2306.2, D2302.3 (K), R2303.2, U2301.5 (+)
/Transceivers/CH23/N2: C2304.1, C2305.1, R2306.2, R2307.1
/Transceivers/CH23/OUT2: C2305.2, R2308.2, R2309.1, U2301.1
/Transceivers/CH23/S1: C2307.2, R2304.2, R2306.1, U2301.7
/Transceivers/CH23/XD: D2301.3 (K), LS2301.1, R2302.1, R2303.1
/Transceivers/CH24/DRV: D2401.1 (K), D2401.2 (A), R2401.2
/Transceivers/CH24/FB1: C2407.1, R2404.1, R2405.1, U2401.6 (-)
/Transceivers/CH24/INV2: C2404.2, R2408.1, U2401.2 (-)
/Transceivers/CH24/LIM: C2406.2, D2402.3 (K), R2403.2, U2401.5 (+)
/Transceivers/CH24/N2: C2404.1, C2405.1, R2406.2, R2407.1
/Transceivers/CH24/OUT2: C2405.2, R2408.2, R2409.1, U2401.1
/Transceivers/CH24/S1: C2407.2, R2404.2, R2406.1, U2401.7
/Transceivers/CH24/XD: D2401.3 (K), LS2401.1, R2402.1, R2403.1
/Transceivers/CH25/DRV: D2501.1 (K), D2501.2 (A), R2501.2
/Transceivers/CH25/FB1: C2507.1, R2504.1, R2505.1, U2501.6 (-)
/Transceivers/CH25/INV2: C2504.2, R2508.1, U2501.2 (-)
/Transceivers/CH25/LIM: C2506.2, D2502.3 (K), R2503.2, U2501.5 (+)
/Transceivers/CH25/N2: C2504.1, C2505.1, R2506.2, R2507.1
/Transceivers/CH25/OUT2: C2505.2, R2508.2, R2509.1, U2501.1
/Transceivers/CH25/S1: C2507.2, R2504.2, R2506.1, U2501.7
/Transceivers/CH25/XD: D2501.3 (K), LS2501.1, R2502.1, R2503.1
/Transceivers/CH26/DRV: D2601.1 (K), D2601.2 (A), R2601.2
/Transceivers/CH26/FB1: C2607.1, R2604.1, R2605.1, U2601.6 (-)
/Transceivers/CH26/INV2: C2604.2, R2608.1, U2601.2 (-)
/Transceivers/CH26/LIM: C2606.2, D2602.3 (K), R2603.2, U2601.5 (+)
/Transceivers/CH26/N2: C2604.1, C2605.1, R2606.2, R2607.1
/Transceivers/CH26/OUT2: C2605.2, R2608.2, R2609.1, U2601.1
/Transceivers/CH26/S1: C2607.2, R2604.2, R2606.1, U2601.7
/Transceivers/CH26/XD: D2601.3 (K), LS2601.1, R2602.1, R2603.1
/Transceivers/CH27/DRV: D2701.1 (K), D2701.2 (A), R2701.2
/Transceivers/CH27/FB1: C2707.1, R2704.1, R2705.1, U2701.6 (-)
/Transceivers/CH27/INV2: C2704.2, R2708.1, U2701.2 (-)
/Transceivers/CH27/LIM: C2706.2, D2702.3 (K), R2703.2, U2701.5 (+)
/Transceivers/CH27/N2: C2704.1, C2705.1, R2706.2, R2707.1
/Transceivers/CH27/OUT2: C2705.2, R2708.2, R2709.1, U2701.1
/Transceivers/CH27/S1: C2707.2, R2704.2, R2706.1, U2701.7
/Transceivers/CH27/XD: D2701.3 (K), LS2701.1, R2702.1, R2703.1
/Transceivers/CH28/DRV: D2801.1 (K), D2801.2 (A), R2801.2
/Transceivers/CH28/FB1: C2807.1, R2804.1, R2805.1, U2801.6 (-)
/Transceivers/CH28/INV2: C2804.2, R2808.1, U2801.2 (-)
/Transceivers/CH28/LIM: C2806.2, D2802.3 (K), R2803.2, U2801.5 (+)
/Transceivers/CH28/N2: C2804.1, C2805.1, R2806.2, R2807.1
/Transceivers/CH28/OUT2: C2805.2, R2808.2, R2809.1, U2801.1
/Transceivers/CH28/S1: C2807.2, R2804.2, R2806.1, U2801.7
/Transceivers/CH28/XD: D2801.3 (K), LS2801.1, R2802.1, R2803.1
/Transceivers/CH29/DRV: D2901.1 (K), D2901.2 (A), R2901.2
/Transceivers/CH29/FB1: C2907.1, R2904.1, R2905.1, U2901.6 (-)
/Transceivers/CH29/INV2: C2904.2, R2908.1, U2901.2 (-)
/Transceivers/CH29/LIM: C2906.2, D2902.3 (K), R2903.2, U2901.5 (+)
/Transceivers/CH29/N2: C2904.1, C2905.1, R2906.2, R2907.1
/Transceivers/CH29/OUT2: C2905.2, R2908.2, R2909.1, U2901.1
/Transceivers/CH29/S1: C2907.2, R2904.2, R2906.1, U2901.7
/Transceivers/CH29/XD: D2901.3 (K), LS2901.1, R2902.1, R2903.1
/Transceivers/CH30/DRV: D3001.1 (K), D3001.2 (A), R3001.2
/Transceivers/CH30/FB1: C3007.1, R3004.1, R3005.1, U3001.6 (-)
/Transceivers/CH30/INV2: C3004.2, R3008.1, U3001.2 (-)
/Transceivers/CH30/LIM: C3006.2, D3002.3 (K), R3003.2, U3001.5 (+)
/Transceivers/CH30/N2: C3004.1, C3005.1, R3006.2, R3007.1
/Transceivers/CH30/OUT2: C3005.2, R3008.2, R3009.1, U3001.1
/Transceivers/CH30/S1: C3007.2, R3004.2, R3006.1, U3001.7
/Transceivers/CH30/XD: D3001.3 (K), LS3001.1, R3002.1, R3003.1
/Transceivers/CH31/DRV: D3101.1 (K), D3101.2 (A), R3101.2
/Transceivers/CH31/FB1: C3107.1, R3104.1, R3105.1, U3101.6 (-)
/Transceivers/CH31/INV2: C3104.2, R3108.1, U3101.2 (-)
/Transceivers/CH31/LIM: C3106.2, D3102.3 (K), R3103.2, U3101.5 (+)
/Transceivers/CH31/N2: C3104.1, C3105.1, R3106.2, R3107.1
/Transceivers/CH31/OUT2: C3105.2, R3108.2, R3109.1, U3101.1
/Transceivers/CH31/S1: C3107.2, R3104.2, R3106.1, U3101.7
/Transceivers/CH31/XD: D3101.3 (K), LS3101.1, R3102.1, R3103.1
/Transceivers/CH32/DRV: D3201.1 (K), D3201.2 (A), R3201.2
/Transceivers/CH32/FB1: C3207.1, R3204.1, R3205.1, U3201.6 (-)
/Transceivers/CH32/INV2: C3204.2, R3208.1, U3201.2 (-)
/Transceivers/CH32/LIM: C3206.2, D3202.3 (K), R3203.2, U3201.5 (+)
/Transceivers/CH32/N2: C3204.1, C3205.1, R3206.2, R3207.1
/Transceivers/CH32/OUT2: C3205.2, R3208.2, R3209.1, U3201.1
/Transceivers/CH32/S1: C3207.2, R3204.2, R3206.1, U3201.7
/Transceivers/CH32/XD: D3201.3 (K), LS3201.1, R3202.1, R3203.1
/Transceivers/CH33/DRV: D3301.1 (K), D3301.2 (A), R3301.2
/Transceivers/CH33/FB1: C3307.1, R3304.1, R3305.1, U3301.6 (-)
/Transceivers/CH33/INV2: C3304.2, R3308.1, U3301.2 (-)
/Transceivers/CH33/LIM: C3306.2, D3302.3 (K), R3303.2, U3301.5 (+)
/Transceivers/CH33/N2: C3304.1, C3305.1, R3306.2, R3307.1
/Transceivers/CH33/OUT2: C3305.2, R3308.2, R3309.1, U3301.1
/Transceivers/CH33/S1: C3307.2, R3304.2, R3306.1, U3301.7
/Transceivers/CH33/XD: D3301.3 (K), LS3301.1, R3302.1, R3303.1
/Transceivers/CH34/DRV: D3401.1 (K), D3401.2 (A), R3401.2
/Transceivers/CH34/FB1: C3407.1, R3404.1, R3405.1, U3401.6 (-)
/Transceivers/CH34/INV2: C3404.2, R3408.1, U3401.2 (-)
/Transceivers/CH34/LIM: C3406.2, D3402.3 (K), R3403.2, U3401.5 (+)
/Transceivers/CH34/N2: C3404.1, C3405.1, R3406.2, R3407.1
/Transceivers/CH34/OUT2: C3405.2, R3408.2, R3409.1, U3401.1
/Transceivers/CH34/S1: C3407.2, R3404.2, R3406.1, U3401.7
/Transceivers/CH34/XD: D3401.3 (K), LS3401.1, R3402.1, R3403.1
/Transceivers/CH35/DRV: D3501.1 (K), D3501.2 (A), R3501.2
/Transceivers/CH35/FB1: C3507.1, R3504.1, R3505.1, U3501.6 (-)
/Transceivers/CH35/INV2: C3504.2, R3508.1, U3501.2 (-)
/Transceivers/CH35/LIM: C3506.2, D3502.3 (K), R3503.2, U3501.5 (+)
/Transceivers/CH35/N2: C3504.1, C3505.1, R3506.2, R3507.1
/Transceivers/CH35/OUT2: C3505.2, R3508.2, R3509.1, U3501.1
/Transceivers/CH35/S1: C3507.2, R3504.2, R3506.1, U3501.7
/Transceivers/CH35/XD: D3501.3 (K), LS3501.1, R3502.1, R3503.1
/Transceivers/CH36/DRV: D3601.1 (K), D3601.2 (A), R3601.2
/Transceivers/CH36/FB1: C3607.1, R3604.1, R3605.1, U3601.6 (-)
/Transceivers/CH36/INV2: C3604.2, R3608.1, U3601.2 (-)
/Transceivers/CH36/LIM: C3606.2, D3602.3 (K), R3603.2, U3601.5 (+)
/Transceivers/CH36/N2: C3604.1, C3605.1, R3606.2, R3607.1
/Transceivers/CH36/OUT2: C3605.2, R3608.2, R3609.1, U3601.1
/Transceivers/CH36/S1: C3607.2, R3604.2, R3606.1, U3601.7
/Transceivers/CH36/XD: D3601.3 (K), LS3601.1, R3602.1, R3603.1
/Transceivers/CH37/DRV: D3701.1 (K), D3701.2 (A), R3701.2
/Transceivers/CH37/FB1: C3707.1, R3704.1, R3705.1, U3701.6 (-)
/Transceivers/CH37/INV2: C3704.2, R3708.1, U3701.2 (-)
/Transceivers/CH37/LIM: C3706.2, D3702.3 (K), R3703.2, U3701.5 (+)
/Transceivers/CH37/N2: C3704.1, C3705.1, R3706.2, R3707.1
/Transceivers/CH37/OUT2: C3705.2, R3708.2, R3709.1, U3701.1
/Transceivers/CH37/S1: C3707.2, R3704.2, R3706.1, U3701.7
/Transceivers/CH37/XD: D3701.3 (K), LS3701.1, R3702.1, R3703.1
/Transceivers/CH38/DRV: D3801.1 (K), D3801.2 (A), R3801.2
/Transceivers/CH38/FB1: C3807.1, R3804.1, R3805.1, U3801.6 (-)
/Transceivers/CH38/INV2: C3804.2, R3808.1, U3801.2 (-)
/Transceivers/CH38/LIM: C3806.2, D3802.3 (K), R3803.2, U3801.5 (+)
/Transceivers/CH38/N2: C3804.1, C3805.1, R3806.2, R3807.1
/Transceivers/CH38/OUT2: C3805.2, R3808.2, R3809.1, U3801.1
/Transceivers/CH38/S1: C3807.2, R3804.2, R3806.1, U3801.7
/Transceivers/CH38/XD: D3801.3 (K), LS3801.1, R3802.1, R3803.1
/Transceivers/CH39/DRV: D3901.1 (K), D3901.2 (A), R3901.2
/Transceivers/CH39/FB1: C3907.1, R3904.1, R3905.1, U3901.6 (-)
/Transceivers/CH39/INV2: C3904.2, R3908.1, U3901.2 (-)
/Transceivers/CH39/LIM: C3906.2, D3902.3 (K), R3903.2, U3901.5 (+)
/Transceivers/CH39/N2: C3904.1, C3905.1, R3906.2, R3907.1
/Transceivers/CH39/OUT2: C3905.2, R3908.2, R3909.1, U3901.1
/Transceivers/CH39/S1: C3907.2, R3904.2, R3906.1, U3901.7
/Transceivers/CH39/XD: D3901.3 (K), LS3901.1, R3902.1, R3903.1
/Transceivers/CH40/DRV: D4001.1 (K), D4001.2 (A), R4001.2
/Transceivers/CH40/FB1: C4007.1, R4004.1, R4005.1, U4001.6 (-)
/Transceivers/CH40/INV2: C4004.2, R4008.1, U4001.2 (-)
/Transceivers/CH40/LIM: C4006.2, D4002.3 (K), R4003.2, U4001.5 (+)
/Transceivers/CH40/N2: C4004.1, C4005.1, R4006.2, R4007.1
/Transceivers/CH40/OUT2: C4005.2, R4008.2, R4009.1, U4001.1
/Transceivers/CH40/S1: C4007.2, R4004.2, R4006.1, U4001.7
/Transceivers/CH40/XD: D4001.3 (K), LS4001.1, R4002.1, R4003.1
/Transceivers/CH41/DRV: D4101.1 (K), D4101.2 (A), R4101.2
/Transceivers/CH41/FB1: C4107.1, R4104.1, R4105.1, U4101.6 (-)
/Transceivers/CH41/INV2: C4104.2, R4108.1, U4101.2 (-)
/Transceivers/CH41/LIM: C4106.2, D4102.3 (K), R4103.2, U4101.5 (+)
/Transceivers/CH41/N2: C4104.1, C4105.1, R4106.2, R4107.1
/Transceivers/CH41/OUT2: C4105.2, R4108.2, R4109.1, U4101.1
/Transceivers/CH41/S1: C4107.2, R4104.2, R4106.1, U4101.7
/Transceivers/CH41/XD: D4101.3 (K), LS4101.1, R4102.1, R4103.1
/Transceivers/CH42/DRV: D4201.1 (K), D4201.2 (A), R4201.2
/Transceivers/CH42/FB1: C4207.1, R4204.1, R4205.1, U4201.6 (-)
/Transceivers/CH42/INV2: C4204.2, R4208.1, U4201.2 (-)
/Transceivers/CH42/LIM: C4206.2, D4202.3 (K), R4203.2, U4201.5 (+)
/Transceivers/CH42/N2: C4204.1, C4205.1, R4206.2, R4207.1
/Transceivers/CH42/OUT2: C4205.2, R4208.2, R4209.1, U4201.1
/Transceivers/CH42/S1: C4207.2, R4204.2, R4206.1, U4201.7
/Transceivers/CH42/XD: D4201.3 (K), LS4201.1, R4202.1, R4203.1
/Transceivers/CH43/DRV: D4301.1 (K), D4301.2 (A), R4301.2
/Transceivers/CH43/FB1: C4307.1, R4304.1, R4305.1, U4301.6 (-)
/Transceivers/CH43/INV2: C4304.2, R4308.1, U4301.2 (-)
/Transceivers/CH43/LIM: C4306.2, D4302.3 (K), R4303.2, U4301.5 (+)
/Transceivers/CH43/N2: C4304.1, C4305.1, R4306.2, R4307.1
/Transceivers/CH43/OUT2: C4305.2, R4308.2, R4309.1, U4301.1
/Transceivers/CH43/S1: C4307.2, R4304.2, R4306.1, U4301.7
/Transceivers/CH43/XD: D4301.3 (K), LS4301.1, R4302.1, R4303.1
/Transceivers/CH44/DRV: D4401.1 (K), D4401.2 (A), R4401.2
/Transceivers/CH44/FB1: C4407.1, R4404.1, R4405.1, U4401.6 (-)
/Transceivers/CH44/INV2: C4404.2, R4408.1, U4401.2 (-)
/Transceivers/CH44/LIM: C4406.2, D4402.3 (K), R4403.2, U4401.5 (+)
/Transceivers/CH44/N2: C4404.1, C4405.1, R4406.2, R4407.1
/Transceivers/CH44/OUT2: C4405.2, R4408.2, R4409.1, U4401.1
/Transceivers/CH44/S1: C4407.2, R4404.2, R4406.1, U4401.7
/Transceivers/CH44/XD: D4401.3 (K), LS4401.1, R4402.1, R4403.1
/Transceivers/CH45/DRV: D4501.1 (K), D4501.2 (A), R4501.2
/Transceivers/CH45/FB1: C4507.1, R4504.1, R4505.1, U4501.6 (-)
/Transceivers/CH45/INV2: C4504.2, R4508.1, U4501.2 (-)
/Transceivers/CH45/LIM: C4506.2, D4502.3 (K), R4503.2, U4501.5 (+)
/Transceivers/CH45/N2: C4504.1, C4505.1, R4506.2, R4507.1
/Transceivers/CH45/OUT2: C4505.2, R4508.2, R4509.1, U4501.1
/Transceivers/CH45/S1: C4507.2, R4504.2, R4506.1, U4501.7
/Transceivers/CH45/XD: D4501.3 (K), LS4501.1, R4502.1, R4503.1
/Transceivers/CH46/DRV: D4601.1 (K), D4601.2 (A), R4601.2
/Transceivers/CH46/FB1: C4607.1, R4604.1, R4605.1, U4601.6 (-)
/Transceivers/CH46/INV2: C4604.2, R4608.1, U4601.2 (-)
/Transceivers/CH46/LIM: C4606.2, D4602.3 (K), R4603.2, U4601.5 (+)
/Transceivers/CH46/N2: C4604.1, C4605.1, R4606.2, R4607.1
/Transceivers/CH46/OUT2: C4605.2, R4608.2, R4609.1, U4601.1
/Transceivers/CH46/S1: C4607.2, R4604.2, R4606.1, U4601.7
/Transceivers/CH46/XD: D4601.3 (K), LS4601.1, R4602.1, R4603.1
/Transceivers/CH47/DRV: D4701.1 (K), D4701.2 (A), R4701.2
/Transceivers/CH47/FB1: C4707.1, R4704.1, R4705.1, U4701.6 (-)
/Transceivers/CH47/INV2: C4704.2, R4708.1, U4701.2 (-)
/Transceivers/CH47/LIM: C4706.2, D4702.3 (K), R4703.2, U4701.5 (+)
/Transceivers/CH47/N2: C4704.1, C4705.1, R4706.2, R4707.1
/Transceivers/CH47/OUT2: C4705.2, R4708.2, R4709.1, U4701.1
/Transceivers/CH47/S1: C4707.2, R4704.2, R4706.1, U4701.7
/Transceivers/CH47/XD: D4701.3 (K), LS4701.1, R4702.1, R4703.1
/Transceivers/CH48/DRV: D4801.1 (K), D4801.2 (A), R4801.2
/Transceivers/CH48/FB1: C4807.1, R4804.1, R4805.1, U4801.6 (-)
/Transceivers/CH48/INV2: C4804.2, R4808.1, U4801.2 (-)
/Transceivers/CH48/LIM: C4806.2, D4802.3 (K), R4803.2, U4801.5 (+)
/Transceivers/CH48/N2: C4804.1, C4805.1, R4806.2, R4807.1
/Transceivers/CH48/OUT2: C4805.2, R4808.2, R4809.1, U4801.1
/Transceivers/CH48/S1: C4807.2, R4804.2, R4806.1, U4801.7
/Transceivers/CH48/XD: D4801.3 (K), LS4801.1, R4802.1, R4803.1
/Transceivers/CH49/DRV: D4901.1 (K), D4901.2 (A), R4901.2
/Transceivers/CH49/FB1: C4907.1, R4904.1, R4905.1, U4901.6 (-)
/Transceivers/CH49/INV2: C4904.2, R4908.1, U4901.2 (-)
/Transceivers/CH49/LIM: C4906.2, D4902.3 (K), R4903.2, U4901.5 (+)
/Transceivers/CH49/N2: C4904.1, C4905.1, R4906.2, R4907.1
/Transceivers/CH49/OUT2: C4905.2, R4908.2, R4909.1, U4901.1
/Transceivers/CH49/S1: C4907.2, R4904.2, R4906.1, U4901.7
/Transceivers/CH49/XD: D4901.3 (K), LS4901.1, R4902.1, R4903.1
/Transceivers/CH50/DRV: D5001.1 (K), D5001.2 (A), R5001.2
/Transceivers/CH50/FB1: C5007.1, R5004.1, R5005.1, U5001.6 (-)
/Transceivers/CH50/INV2: C5004.2, R5008.1, U5001.2 (-)
/Transceivers/CH50/LIM: C5006.2, D5002.3 (K), R5003.2, U5001.5 (+)
/Transceivers/CH50/N2: C5004.1, C5005.1, R5006.2, R5007.1
/Transceivers/CH50/OUT2: C5005.2, R5008.2, R5009.1, U5001.1
/Transceivers/CH50/S1: C5007.2, R5004.2, R5006.1, U5001.7
/Transceivers/CH50/XD: D5001.3 (K), LS5001.1, R5002.1, R5003.1
/Transceivers/CH51/DRV: D5101.1 (K), D5101.2 (A), R5101.2
/Transceivers/CH51/FB1: C5107.1, R5104.1, R5105.1, U5101.6 (-)
/Transceivers/CH51/INV2: C5104.2, R5108.1, U5101.2 (-)
/Transceivers/CH51/LIM: C5106.2, D5102.3 (K), R5103.2, U5101.5 (+)
/Transceivers/CH51/N2: C5104.1, C5105.1, R5106.2, R5107.1
/Transceivers/CH51/OUT2: C5105.2, R5108.2, R5109.1, U5101.1
/Transceivers/CH51/S1: C5107.2, R5104.2, R5106.1, U5101.7
/Transceivers/CH51/XD: D5101.3 (K), LS5101.1, R5102.1, R5103.1
/Transceivers/CH52/DRV: D5201.1 (K), D5201.2 (A), R5201.2
/Transceivers/CH52/FB1: C5207.1, R5204.1, R5205.1, U5201.6 (-)
/Transceivers/CH52/INV2: C5204.2, R5208.1, U5201.2 (-)
/Transceivers/CH52/LIM: C5206.2, D5202.3 (K), R5203.2, U5201.5 (+)
/Transceivers/CH52/N2: C5204.1, C5205.1, R5206.2, R5207.1
/Transceivers/CH52/OUT2: C5205.2, R5208.2, R5209.1, U5201.1
/Transceivers/CH52/S1: C5207.2, R5204.2, R5206.1, U5201.7
/Transceivers/CH52/XD: D5201.3 (K), LS5201.1, R5202.1, R5203.1
/Transceivers/CH53/DRV: D5301.1 (K), D5301.2 (A), R5301.2
/Transceivers/CH53/FB1: C5307.1, R5304.1, R5305.1, U5301.6 (-)
/Transceivers/CH53/INV2: C5304.2, R5308.1, U5301.2 (-)
/Transceivers/CH53/LIM: C5306.2, D5302.3 (K), R5303.2, U5301.5 (+)
/Transceivers/CH53/N2: C5304.1, C5305.1, R5306.2, R5307.1
/Transceivers/CH53/OUT2: C5305.2, R5308.2, R5309.1, U5301.1
/Transceivers/CH53/S1: C5307.2, R5304.2, R5306.1, U5301.7
/Transceivers/CH53/XD: D5301.3 (K), LS5301.1, R5302.1, R5303.1
/Transceivers/CH54/DRV: D5401.1 (K), D5401.2 (A), R5401.2
/Transceivers/CH54/FB1: C5407.1, R5404.1, R5405.1, U5401.6 (-)
/Transceivers/CH54/INV2: C5404.2, R5408.1, U5401.2 (-)
/Transceivers/CH54/LIM: C5406.2, D5402.3 (K), R5403.2, U5401.5 (+)
/Transceivers/CH54/N2: C5404.1, C5405.1, R5406.2, R5407.1
/Transceivers/CH54/OUT2: C5405.2, R5408.2, R5409.1, U5401.1
/Transceivers/CH54/S1: C5407.2, R5404.2, R5406.1, U5401.7
/Transceivers/CH54/XD: D5401.3 (K), LS5401.1, R5402.1, R5403.1
/Transceivers/CH55/DRV: D5501.1 (K), D5501.2 (A), R5501.2
/Transceivers/CH55/FB1: C5507.1, R5504.1, R5505.1, U5501.6 (-)
/Transceivers/CH55/INV2: C5504.2, R5508.1, U5501.2 (-)
/Transceivers/CH55/LIM: C5506.2, D5502.3 (K), R5503.2, U5501.5 (+)
/Transceivers/CH55/N2: C5504.1, C5505.1, R5506.2, R5507.1
/Transceivers/CH55/OUT2: C5505.2, R5508.2, R5509.1, U5501.1
/Transceivers/CH55/S1: C5507.2, R5504.2, R5506.1, U5501.7
/Transceivers/CH55/XD: D5501.3 (K), LS5501.1, R5502.1, R5503.1
/Transceivers/CH56/DRV: D5601.1 (K), D5601.2 (A), R5601.2
/Transceivers/CH56/FB1: C5607.1, R5604.1, R5605.1, U5601.6 (-)
/Transceivers/CH56/INV2: C5604.2, R5608.1, U5601.2 (-)
/Transceivers/CH56/LIM: C5606.2, D5602.3 (K), R5603.2, U5601.5 (+)
/Transceivers/CH56/N2: C5604.1, C5605.1, R5606.2, R5607.1
/Transceivers/CH56/OUT2: C5605.2, R5608.2, R5609.1, U5601.1
/Transceivers/CH56/S1: C5607.2, R5604.2, R5606.1, U5601.7
/Transceivers/CH56/XD: D5601.3 (K), LS5601.1, R5602.1, R5603.1
/Transceivers/CH57/DRV: D5701.1 (K), D5701.2 (A), R5701.2
/Transceivers/CH57/FB1: C5707.1, R5704.1, R5705.1, U5701.6 (-)
/Transceivers/CH57/INV2: C5704.2, R5708.1, U5701.2 (-)
/Transceivers/CH57/LIM: C5706.2, D5702.3 (K), R5703.2, U5701.5 (+)
/Transceivers/CH57/N2: C5704.1, C5705.1, R5706.2, R5707.1
/Transceivers/CH57/OUT2: C5705.2, R5708.2, R5709.1, U5701.1
/Transceivers/CH57/S1: C5707.2, R5704.2, R5706.1, U5701.7
/Transceivers/CH57/XD: D5701.3 (K), LS5701.1, R5702.1, R5703.1
/Transceivers/CH58/DRV: D5801.1 (K), D5801.2 (A), R5801.2
/Transceivers/CH58/FB1: C5807.1, R5804.1, R5805.1, U5801.6 (-)
/Transceivers/CH58/INV2: C5804.2, R5808.1, U5801.2 (-)
/Transceivers/CH58/LIM: C5806.2, D5802.3 (K), R5803.2, U5801.5 (+)
/Transceivers/CH58/N2: C5804.1, C5805.1, R5806.2, R5807.1
/Transceivers/CH58/OUT2: C5805.2, R5808.2, R5809.1, U5801.1
/Transceivers/CH58/S1: C5807.2, R5804.2, R5806.1, U5801.7
/Transceivers/CH58/XD: D5801.3 (K), LS5801.1, R5802.1, R5803.1
/Transceivers/CH59/DRV: D5901.1 (K), D5901.2 (A), R5901.2
/Transceivers/CH59/FB1: C5907.1, R5904.1, R5905.1, U5901.6 (-)
/Transceivers/CH59/INV2: C5904.2, R5908.1, U5901.2 (-)
/Transceivers/CH59/LIM: C5906.2, D5902.3 (K), R5903.2, U5901.5 (+)
/Transceivers/CH59/N2: C5904.1, C5905.1, R5906.2, R5907.1
/Transceivers/CH59/OUT2: C5905.2, R5908.2, R5909.1, U5901.1
/Transceivers/CH59/S1: C5907.2, R5904.2, R5906.1, U5901.7
/Transceivers/CH59/XD: D5901.3 (K), LS5901.1, R5902.1, R5903.1
/Transceivers/CH60/DRV: D6001.1 (K), D6001.2 (A), R6001.2
/Transceivers/CH60/FB1: C6007.1, R6004.1, R6005.1, U6001.6 (-)
/Transceivers/CH60/INV2: C6004.2, R6008.1, U6001.2 (-)
/Transceivers/CH60/LIM: C6006.2, D6002.3 (K), R6003.2, U6001.5 (+)
/Transceivers/CH60/N2: C6004.1, C6005.1, R6006.2, R6007.1
/Transceivers/CH60/OUT2: C6005.2, R6008.2, R6009.1, U6001.1
/Transceivers/CH60/S1: C6007.2, R6004.2, R6006.1, U6001.7
/Transceivers/CH60/XD: D6001.3 (K), LS6001.1, R6002.1, R6003.1
/Transceivers/CH61/DRV: D6101.1 (K), D6101.2 (A), R6101.2
/Transceivers/CH61/FB1: C6107.1, R6104.1, R6105.1, U6101.6 (-)
/Transceivers/CH61/INV2: C6104.2, R6108.1, U6101.2 (-)
/Transceivers/CH61/LIM: C6106.2, D6102.3 (K), R6103.2, U6101.5 (+)
/Transceivers/CH61/N2: C6104.1, C6105.1, R6106.2, R6107.1
/Transceivers/CH61/OUT2: C6105.2, R6108.2, R6109.1, U6101.1
/Transceivers/CH61/S1: C6107.2, R6104.2, R6106.1, U6101.7
/Transceivers/CH61/XD: D6101.3 (K), LS6101.1, R6102.1, R6103.1
/Transceivers/CH62/DRV: D6201.1 (K), D6201.2 (A), R6201.2
/Transceivers/CH62/FB1: C6207.1, R6204.1, R6205.1, U6201.6 (-)
/Transceivers/CH62/INV2: C6204.2, R6208.1, U6201.2 (-)
/Transceivers/CH62/LIM: C6206.2, D6202.3 (K), R6203.2, U6201.5 (+)
/Transceivers/CH62/N2: C6204.1, C6205.1, R6206.2, R6207.1
/Transceivers/CH62/OUT2: C6205.2, R6208.2, R6209.1, U6201.1
/Transceivers/CH62/S1: C6207.2, R6204.2, R6206.1, U6201.7
/Transceivers/CH62/XD: D6201.3 (K), LS6201.1, R6202.1, R6203.1
/Transceivers/CH63/DRV: D6301.1 (K), D6301.2 (A), R6301.2
/Transceivers/CH63/FB1: C6307.1, R6304.1, R6305.1, U6301.6 (-)
/Transceivers/CH63/INV2: C6304.2, R6308.1, U6301.2 (-)
/Transceivers/CH63/LIM: C6306.2, D6302.3 (K), R6303.2, U6301.5 (+)
/Transceivers/CH63/N2: C6304.1, C6305.1, R6306.2, R6307.1
/Transceivers/CH63/OUT2: C6305.2, R6308.2, R6309.1, U6301.1
/Transceivers/CH63/S1: C6307.2, R6304.2, R6306.1, U6301.7
/Transceivers/CH63/XD: D6301.3 (K), LS6301.1, R6302.1, R6303.1
/Transceivers/CH64/DRV: D6401.1 (K), D6401.2 (A), R6401.2
/Transceivers/CH64/FB1: C6407.1, R6404.1, R6405.1, U6401.6 (-)
/Transceivers/CH64/INV2: C6404.2, R6408.1, U6401.2 (-)
/Transceivers/CH64/LIM: C6406.2, D6402.3 (K), R6403.2, U6401.5 (+)
/Transceivers/CH64/N2: C6404.1, C6405.1, R6406.2, R6407.1
/Transceivers/CH64/OUT2: C6405.2, R6408.2, R6409.1, U6401.1
/Transceivers/CH64/S1: C6407.2, R6404.2, R6406.1, U6401.7
/Transceivers/CH64/XD: D6401.3 (K), LS6401.1, R6402.1, R6403.1
DRV2: R201.1; also elsewhere on the board
DRV3: R301.1; also elsewhere on the board
DRV4: R401.1; also elsewhere on the board
DRV5: R501.1; also elsewhere on the board
DRV6: R601.1; also elsewhere on the board
DRV7: R701.1; also elsewhere on the board
DRV8: R801.1; also elsewhere on the board
DRV9: R901.1; also elsewhere on the board
DRV10: R1001.1; also elsewhere on the board
DRV11: R1101.1; also elsewhere on the board
DRV12: R1201.1; also elsewhere on the board
DRV13: R1301.1; also elsewhere on the board
DRV14: R1401.1; also elsewhere on the board
DRV15: R1501.1; also elsewhere on the board
DRV16: R1601.1; also elsewhere on the board
DRV17: R1701.1; also elsewhere on the board
DRV18: R1801.1; also elsewhere on the board
DRV19: R1901.1; also elsewhere on the board
DRV20: R2001.1; also elsewhere on the board
DRV21: R2101.1; also elsewhere on the board
DRV22: R2201.1; also elsewhere on the board
DRV23: R2301.1; also elsewhere on the board
DRV24: R2401.1; also elsewhere on the board
DRV25: R2501.1; also elsewhere on the board
DRV26: R2601.1; also elsewhere on the board
DRV27: R2701.1; also elsewhere on the board
DRV28: R2801.1; also elsewhere on the board
DRV29: R2901.1; also elsewhere on the board
DRV30: R3001.1; also elsewhere on the board
DRV31: R3101.1; also elsewhere on the board
DRV32: R3201.1; also elsewhere on the board
DRV33: R3301.1; also elsewhere on the board
DRV34: R3401.1; also elsewhere on the board
DRV35: R3501.1; also elsewhere on the board
DRV36: R3601.1; also elsewhere on the board
DRV37: R3701.1; also elsewhere on the board
DRV38: R3801.1; also elsewhere on the board
DRV39: R3901.1; also elsewhere on the board
DRV40: R4001.1; also elsewhere on the board
DRV41: R4101.1; also elsewhere on the board
DRV42: R4201.1; also elsewhere on the board
DRV43: R4301.1; also elsewhere on the board
DRV44: R4401.1; also elsewhere on the board
DRV45: R4501.1; also elsewhere on the board
DRV46: R4601.1; also elsewhere on the board
DRV47: R4701.1; also elsewhere on the board
DRV48: R4801.1; also elsewhere on the board
DRV49: R4901.1; also elsewhere on the board
DRV50: R5001.1; also elsewhere on the board
DRV51: R5101.1; also elsewhere on the board
DRV52: R5201.1; also elsewhere on the board
DRV53: R5301.1; also elsewhere on the board
DRV54: R5401.1; also elsewhere on the board
DRV55: R5501.1; also elsewhere on the board
DRV56: R5601.1; also elsewhere on the board
DRV57: R5701.1; also elsewhere on the board
DRV58: R5801.1; also elsewhere on the board
DRV59: R5901.1; also elsewhere on the board
DRV60: R6001.1; also elsewhere on the board
DRV61: R6101.1; also elsewhere on the board
DRV62: R6201.1; also elsewhere on the board
DRV63: R6301.1; also elsewhere on the board
DRV64: R6401.1; also elsewhere on the board
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
Notes on the sheet:
Transceiver channel (one of 64). TX: UCC27524 half -> 47 R -> BAV99 crossed diodes -> element (0-15 V square).
33k bleed resets the element after TX. RX: 4.7k + BAV99 clamp (+-0.7 V) + 100 pF (340 kHz RF filter).
OPA1678 stage 1: gain 6, AC-coupled at 800 Hz. Stage 2: MFB band-pass f0 39.8 kHz, Q 2, gain -4. Then 100 R to the ADC.
Element -> amplifier out +27 dB (x22), -> ADC pin +16.5 dB after the ADC cell's 2k/1k divider; pass band 31-51 kHz (sim/reports/rx_chain.md). Band-pass parts 1 % C0G.
