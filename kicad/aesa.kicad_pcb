# Repository tieziyun/ultrasonic-aesa (continued)

## KiCad design kicad/aesa.kicad_pcb (continued)

Schematic: power_analog.kicad_sch, Power 2 (analog): +-6V5, +-5VA, +3V3A

Parts:
C11, C12, C24, C25, C40, C41: 10u 16V X7R 1206; C_1206_3216Metric; LCSC C380363
C13: 100n 16V X7R; C_0603_1608Metric; LCSC C14663
C14: 6.8p 50V C0G; C_0603_1608Metric; LCSC C1679
C15, C16, C21, C22, C23, C27, C39: 10u 25V X7R 1206; C_1206_3216Metric; LCSC C380364
C17: 7.5p 50V C0G; C_0603_1608Metric; LCSC C53424
C18: 220n 16V X7R; C_0603_1608Metric; LCSC C21120
C19: 10n 16V X7R; C_0603_1608Metric; LCSC C57112
C20: 4.7n 50V C0G; C_0603_1608Metric; LCSC C3904926
C26, C28, C42: 1u 16V X7R; C_0603_1608Metric; LCSC C388002
C29: 10n 50V C0G; C_0603_1608Metric; LCSC C76599
C30: 22u 16V X7R 1210; C_1210_3225Metric; LCSC C412624
C47, C48: 470p 50V C0G DNP; C_0603_1608Metric; LCSC C376788 (DNP); not fitted
D4, D6: SS14; D_SMA; LCSC C2480
D5, D7: green; LED_0603_1608Metric; LCSC C12624
JP2, JP3, JP5, JP6, JP7: cut to isolate; SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm; LCSC none (copper)
L2, L3: 4.7u Isat>=2A; L_Sunlord_SWPA6045S; LCSC C78804
R7: 100 1%; R_0603_1608Metric; LCSC C22775
R8: 562k 1%; R_0603_1608Metric; LCSC C321950
R9: 130k 1%; R_0603_1608Metric; LCSC C22795
R10, R13: 3.3k 1%; R_0603_1608Metric; LCSC C22978
R11: 649k 1%; R_0603_1608Metric; LCSC C25821
R12: 121k 1%; R_0603_1608Metric; LCSC C48996814
R14: 715k 1%; R_0603_1608Metric; LCSC C321989
R15: 220k 1%; R_0603_1608Metric; LCSC C22961
R29, R30: 4.7 1% DNP; R_0603_1608Metric; LCSC C23164 (DNP); not fitted
TP3: +6V5; TestPoint_Pad_D1.5mm; LCSC none (copper)
TP4: -6V5; TestPoint_Pad_D1.5mm; LCSC none (copper)
TP5: +5VA; TestPoint_Pad_D1.5mm; LCSC none (copper)
TP6: -5VA; TestPoint_Pad_D1.5mm; LCSC none (copper)
TP12: +3V3A; TestPoint_Pad_D1.5mm; LCSC none (copper)
U2: TPS65131RGER; VQFN-24-1EP_4x4mm_P0.5mm_EP2.45x2.45mm_ThermalVias; LCSC C87663
U3, U7: TPS7A4700RGWT; Texas_RGW0020A_VQFN-20-1EP_5x5mm_P0.65mm_EP3.15x3.15mm_Ther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; LCSC C28286
U4: TPS7A3301RGWR; Texas_RGW0020A_VQFN-20-1EP_5x5mm_P0.65mm_EP3.15x3.15mm_Ther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; LCSC C90082

Parts of its further copies:
C9511, C9512, C9524, C9525, C9540, C9541: 10u 16V X7R 1206; C_1206_3216Metric; LCSC C380363
C9513: 100n 16V X7R; C_0603_1608Metric; LCSC C14663
C9514: 6.8p 50V C0G; C_0603_1608Metric; LCSC C1679
C9515, C9516, C9521, C9522, C9523, C9527, C9539: 10u 25V X7R 1206; C_1206_3216Metric; LCSC C380364
C9517: 7.5p 50V C0G; C_0603_1608Metric; LCSC C53424
C9518: 220n 16V X7R; C_0603_1608Metric; LCSC C21120
C9519: 10n 16V X7R; C_0603_1608Metric; LCSC C57112
C9520: 4.7n 50V C0G; C_0603_1608Metric; LCSC C3904926
C9526, C9528, C9542: 1u 16V X7R; C_0603_1608Metric; LCSC C388002
C9529: 10n 50V C0G; C_0603_1608Metric; LCSC C76599
C9530: 22u 16V X7R 1210; C_1210_3225Metric; LCSC C412624
C9547, C9548: 470p 50V C0G DNP; C_0603_1608Metric; LCSC C376788 (DNP); not fitted
D9504, D9506: SS14; D_SMA; LCSC C2480
D9505, D9507: green; LED_0603_1608Metric; LCSC C12624
JP9502, JP9503, JP9505, JP9506, JP9507: cut to isolate; SolderJumper-2_P1.3mm_Bridged_RoundedPad1.0x1.5mm; LCSC none (copper)
L9502, L9503: 4.7u Isat>=2A; L_Sunlord_SWPA6045S; LCSC C78804
R9507: 100 1%; R_0603_1608Metric; LCSC C22775
R9508: 562k 1%; R_0603_1608Metric; LCSC C321950
R9509: 130k 1%; R_0603_1608Metric; LCSC C22795
R9510, R9513: 3.3k 1%; R_0603_1608Metric; LCSC C22978
R9511: 649k 1%; R_0603_1608Metric; LCSC C25821
R9512: 121k 1%; R_0603_1608Metric; LCSC C48996814
R9514: 715k 1%; R_0603_1608Metric; LCSC C321989
R9515: 220k 1%; R_0603_1608Metric; LCSC C22961
R9529, R9530: 4.7 1% DNP; R_0603_1608Metric; LCSC C23164 (DNP); not fitted
TP9503: +6V5; TestPoint_Pad_D1.5mm; LCSC none (copper)
TP9504: -6V5; TestPoint_Pad_D1.5mm; LCSC none (copper)
TP9505: +5VA; TestPoint_Pad_D1.5mm; LCSC none (copper)
TP9506: -5VA; TestPoint_Pad_D1.5mm; LCSC none (copper)
TP9512: +3V3A; TestPoint_Pad_D1.5mm; LCSC none (copper)
U9502: TPS65131RGER; VQFN-24-1EP_4x4mm_P0.5mm_EP2.45x2.45mm_ThermalVias; LCSC C87663
U9503, U9507: TPS7A4700RGWT; Texas_RGW0020A_VQFN-20-1EP_5x5mm_P0.65mm_EP3.15x3.15mm_Ther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; LCSC C28286
U9504: TPS7A3301RGWR; Texas_RGW0020A_VQFN-20-1EP_5x5mm_P0.65mm_EP3.15x3.15mm_Ther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; LCSC C90082

Connections of its further copies:
+3V3A: JP9507.2 (B), TP9512.1; also elsewhere on the board
+5V: C9511.1, C9512.1, C9539.1, L9502.1, R9507.1, U9502.5 (INN), U9502.6 (INN), U9502.8 (ENP), U9502.10 (ENN), U9507.13 (EN), U9507.15 (IN), U9507.16 (IN); also elsewhere on the board
+5VA: JP9502.2 (B), TP9505.1; also elsewhere on the board
+6V5: C9523.1, JP9505.2 (B), R9510.1, TP9503.1, U9503.13 (EN), U9503.15 (IN), U9503.16 (IN)
-5VA: JP9503.2 (B), TP9506.1; also elsewhere on the board
-6V5: C9527.1, JP9506.2 (B), R9513.1, TP9504.1, U9504.13 (EN), U9504.15 (IN), U9504.16 (IN)
/Power 2 (analog)/3V3A_REG: C9540.1, C9541.1, JP9507.1 (A), U9507.1 (OUT), U9507.3 (SENSE/FB), U9507.20 (OUT)
/Power 2 (analog)/5VA_REG: C9524.1, C9525.1, JP9502.1 (A), U9503.1 (OUT), U9503.3 (SENSE/FB), U9503.20 (OUT)
/Power 2 (analog)/6V5_REG: C9514.1, C9515.1, C9516.1, D9504.1 (K), JP9505.1 (A), R9508.1, U9502.23 (VPOS)
/Power 2 (analog)/-5VA_REG: C9529.1, C9530.1, JP9503.1 (A), R9514.1, U9504.1 (OUT), U9504.20 (OUT)
/Power 2 (analog)/-6V5_REG: C9517.2, C9521.1, C9522.1, D9506.2 (A), JP9506.1 (A), R9511.2, U9502.15 (VNEG)
/Power 2 (analog)/FBN: C9517.1, R9511.1, R9512.2, U9502.16 (FBN)
/Power 2 (analog)/FBP: C9514.2, R9508.2, R9509.1, U9502.22 (FBP)
/Power 2 (analog)/FB_M5VA: C9529.2, R9514.2, R9515.1, U9504.3 (FB)
/Power 2 (analog)/NR_3V3A: C9542.1, U9507.14 (NR)
/Power 2 (analog)/NR_5VA: C9526.1, U9503.14 (NR)
/Power 2 (analog)/NR_M5VA: C9528.1, U9504.14 (NR/SS)
/Power 2 (analog)/SW_N: D9506.1 (K), L9503.1, R9530.1, U9502.13 (OUTN), U9502.14 (OUTN)
/Power 2 (analog)/SW_P: D9504.2 (A), L9502.2, R9529.1, U9502.1 (INP), U9502.24 (INP)
/Power 2 (analog)/VIN65: C9513.1, R9507.2, U9502.4 (VIN)
/Power 2 (analog)/VREF65: C9518.1, R9512.1, U9502.17 (VREF)
GND: C9511.2, C9512.2, C9513.2, C9515.2, C9516.2, C9518.2, C9519.2, C9520.2, C9521.2, C9522.2, C9523.2, C9524.2, C9525.2, C9526.2, C9527.2, C9528.2, C9530.2, C9539.2, C9540.2, C9541.2, C9542.2, C9547.2, C9548.2, D9505.1 (K), D9507.2 (A), L9503.2, R9509.2, R9515.2, U9502.2 (PGND), U9502.3 (PGND), U9502.9 (PSP), U9502.11 (PSN), U9502.19 (AGND), U9502.25 (EP), U9503.6 (3.2V), U9503.7 (GND), U9503.10 (0.4V), U9503.21 (EP), U9504.7 (GND), U9504.21 (EP), U9507.7 (GND), U9507.8 (1.6V), U9507.11 (0.2V), U9507.12 (0.1V), U9507.21 (EP); also elsewhere on the board
unnamed: C9547.1, R9529.2
unnamed: C9548.1, R9530.2
unnamed: D9505.2 (A), R9510.2
unnamed: D9507.1 (K), R9513.2
unnamed: C9520.1, U9502.18 (CN)
unnamed: C9519.1, U9502.21 (CP)

Notes on the sheet:
limited to 0.3 A. Expect at the test points:
Drawn with the pin-identical TPS65130 symbol: order TPS65131RGER (2 A switches). PSP/PSN low: fixed-frequency PWM. R9529 + C9547 and R9530 + C9548: switch-node snubbers,
3V3_MIC) and the ground test points. Power 2:
POWER TREE, BRING-UP
7. +-5VA: low-noise LDOs TPS7A4700 U9503 / TPS7A3301 U9504
+6V5 = 1.213 V x (1 + 562k/130k) = 6.46 V (R9508 / R9509). -6V5 = -1.213 V x 649k/121k = -6.51 V (R9511 / R9512).
sections 6-8 (+-6V5, +-5VA, +3V3A).
Load about 0.45 A; 0.8 W in the LDO, thermal vias under the pad.
side (*_REG) and the load side apart.
-> VDRV.
DNP (fit only if a switch node rings).
-5VA -5.00 V, +3V3A 3.30 V.
Then fit the J9502 shunt: VDRV 15.4 V.
+-5VA (receivers).
IMON (TP9514) 1.08 V per A in. FLT (TP9515) high
VIN 12 V, +5V 5.07 V, +3V3 3.30 V, 3V3_MIC 3.3 V,
First power-up: J9502 shunt off, bench supply 12 V
6. +-6V5: TPS65131RGER U9502, boost + inverter from +5V (feeds the analog LDOs only)
6. +5V -> U9502 -> +-6V5 -> 7. LDOs U9503 / U9504 ->
A wrong rail: cut its jumper, measure the regulator
3. +5V -> LDO U9506 -> +3V3 -> 5. FB9501 -> 3V3_MIC.
8. +3V3A: TPS7A4700 low-noise LDO U9507 from +5V
2. VIN -> buck U9501 -> +5V. 4. VIN -> boost U9505
Load: 64 x OPA1678 (4 mA per channel), about 0.3 A on each rail. Analog rails: no LEDs.
1. 12 V jack J9501 -> eFuse U9508 -> F9501 -> VIN.
AVDD of the 16 ADCs (analog rail: no LED). ANY-OUT 1.4 + 1.6 + 0.2 + 0.1 = 3.3 V.
8. +5V -> LDO U9507 -> +3V3A (ADC AVDD).
+6V5 6.46 V, -6V5 -6.51 V, +5VA 5.00 V,
Power 1: sections 1-5 (input, +5V, +3V3, VDRV,
(low = eFuse fault).
+5VA: ANY-OUT 1.4 + 3.2 + 0.4 = 5.0 V. -5VA = -1.176 V x (1 + 715k/220k) = -5.00 V.

Schematic: clk_buf.kicad_sch, Clock buffer (x10): 74LVC2G34, 47 R outputs

Parts:
C1: 100n 16V X7R; C_0603_1608Metric; LCSC C14663
R1, R2: 47 1%; R_0603_1608Metric; LCSC C23182
R3: 100k 1%; R_0603_1608Metric; LCSC C25803
U1: 74LVC2G34; SOT-363_SC-70-6; LCSC C52140488

Parts of its further copies:
C13101, C13201, C13301, C13401, C13501, C13601, C13701, C13801, C13901, C14001: 100n 16V X7R; C_0603_1608Metric; LCSC C14663
R13101, R13102, R13201, R13202, R13301, R13302, R13401, R13402, R13501, R13502, R13601, R13602, R13701, R13702, R13801, R13802, R13901, R13902, R14001, R14002: 47 1%; R_0603_1608Metric; LCSC C23182
R13103, R13203, R13303, R13403, R13503, R13603, R13703, R13803, R13903, R14003: 100k 1%; R_0603_1608Metric; LCSC C25803
U13101, U13201, U13301, U13401, U13501, U13601, U13701, U13801, U13901, U14001: 74LVC2G34; SOT-363_SC-70-6; LCSC C52140488

Connections of its further copies:
+3V3: C13101.1, C13201.1, C13301.1, C13401.1, C13501.1, C13601.1, C13701.1, C13801.1, C13901.1, C14001.1, U13101.5 (VCC), U13201.5 (VCC), U13301.5 (VCC), U13401.5 (VCC), U13501.5 (VCC), U13601.5 (VCC), U13701.5 (VCC), U13801.5 (VCC), U13901.5 (VCC), U14001.5 (VCC); also elsewhere on the board
ADC_BCLK: R13503.1, R13603.1, U13501.1, U13501.3, U13601.1, U13601.3; also elsewhere on the board
ADC_BCLK_A: R13501.2; also elsewhere on the board
ADC_BCLK_B: R13502.2; also elsewhere on the board
ADC_BCLK_C: R13601.2; also elsewhere on the board
ADC_BCLK_D: R13602.2; also elsewhere on the board
ADC_FSYNC: R13703.1, R13803.1, U13701.1, U13701.3, U13801.1, U13801.3; also elsewhere on the board
ADC_FSYNC_A: R13701.2; also elsewhere on the board
ADC_FSYNC_B: R13702.2; also elsewhere on the board
ADC_FSYNC_C: R13801.2; also elsewhere on the board
ADC_FSYNC_D: R13802.2; also elsewhere on the board
GND: C13101.2, C13201.2, C13301.2, C13401.2, C13501.2, C13601.2, C13701.2, C13801.2, C13901.2, C14001.2, R13103.2, R13203.2, R13303.2, R13403.2, R13503.2, R13603.2, R13703.2, R13803.2, R13903.2, R14003.2, U13101.2 (GND), U13201.2 (GND), U13301.2 (GND), U13401.2 (GND), U13501.2 (GND), U13601.2 (GND), U13701.2 (GND), U13801.2 (GND), U13901.2 (GND), U14001.2 (GND); also elsewhere on the board
MIC_CLK_A: R13901.2; also elsewhere on the board
MIC_CLK_B: R13902.2; also elsewhere on the board
MIC_CLK_C: R14001.2; also elsewhere on the board
MIC_CLK_D: R14002.2; also elsewhere on the board
MIC_CLK_IN: R13903.1, R14003.1, U13901.1, U13901.3, U14001.1, U14001.3; also elsewhere on the board
unnamed: R13101.1, U13101.6
unnamed: R13102.1, U13101.4
unnamed: R13201.1, U13201.6
unnamed: R13202.1, U13201.4
unnamed: R13301.1, U13301.6
unnamed: R13302.1, U13301.4
unnamed: R13401.1, U13401.6
unnamed: R13402.1, U13401.4
unnamed: R13501.1, U13501.6
unnamed: R13502.1, U13501.4
unnamed: R13601.1, U13601.6
unnamed: R13602.1, U13601.4
unnamed: R13701.1, U13701.6
unnamed: R13702.1, U13701.4
unnamed: R13801.1, U13801.6
unnamed: R13802.1, U13801.4
unnamed: R13901.1, U13901.6
unnamed: R13902.1, U13901.4
unnamed: R14001.1, U14001.6
unnamed: R14002.1, U14001.4
TX_LATCH: R13303.1, R13403.1, U13301.1, U13301.3, U13401.1, U13401.3; also elsewhere on the board
TX_LATCH_A: R13301.2; also elsewhere on the board
TX_LATCH_B: R13302.2; also elsewhere on the board
TX_LATCH_C: R13401.2; also elsewhere on the board
TX_LATCH_D: R13402.2; also elsewhere on the board
TX_SCK: R13103.1, R13203.1, U13101.1, U13101.3, U13201.1, U13201.3; also elsewhere on the board
TX_SCK_A: R13101.2; also elsewhere on the board
TX_SCK_B: R13102.2; also elsewhere on the board
TX_SCK_C: R13201.2; also elsewhere on the board
TX_SCK_D: R13202.2; also elsewhere on the board

Notes on the sheet:
Each output drives at most 4 loads, clustered at the far end of its trace (series termination needs that: sim/reports/mic_clock_si.md).
100 k pull-down keeps the clock low while the FPGA is unconfigured.
Clock fan-out: 74LVC2G34, both gates on IN, 47 R series termination per output (with the ~20 R driver: matches the 61 ohm 0.25 mm clock traces)

Schematic: tx_group.kicad_sch, TX group (x16): 74HCT595 + 2 x UCC27524, 4 elements

Parts:
C1: 100n 16V X7R; C_0603_1608Metric; LCSC C14663
C2, C4: 1u 50V X7R; C_0805_2012Metric; LCSC C28323
C3, C5: 100n 50V X7R; C_0603_1608Metric; LCSC C14663
U1: 74HCT595D; SOIC-16_3.9x9.9mm_P1.27mm; LCSC C282339
U2, U3: UCC27524DR; SOIC-8_3.9x4.9mm_P1.27mm; LCSC C465729

Parts of its further copies:
C10101, C10201, C10301, C10401, C10501, C10601, C10701, C10801, C10901, C11001, C11101, C11201, C11301, C11401, C11501, C11601: 100n 16V X7R; C_0603_1608Metric; LCSC C14663
C10102, C10104, C10202, C10204, C10302, C10304, C10402, C10404, C10502, C10504, C10602, C10604, C10702, C10704, C10802, C10804, C10902, C10904, C11002, C11004, C11102, C11104, C11202, C11204, C11302, C11304, C11402, C11404, C11502, C11504, C11602, C11604: 1u 50V X7R; C_0805_2012Metric; LCSC C28323
C10103, C10105, C10203, C10205, C10303, C10305, C10403, C10405, C10503, C10505, C10603, C10605, C10703, C10705, C10803, C10805, C10903, C10905, C11003, C11005, C11103, C11105, C11203, C11205, C11303, C11305, C11403, C11405, C11503, C11505, C11603, C11605: 100n 50V X7R; C_0603_1608Metric; LCSC C14663
U10101, U10201, U10301, U10401, U10501, U10601, U10701, U10801, U10901, U11001, U11101, U11201, U11301, U11401, U11501, U11601: 74HCT595D; SOIC-16_3.9x9.9mm_P1.27mm; LCSC C282339
U10102, U10103, U10202, U10203, U10302, U10303, U10402, U10403, U10502, U10503, U10602, U10603, U10702, U10703, U10802, U10803, U10902, U10903, U11002, U11003, U11102, U11103, U11202, U11203, U11302, U11303, U11402, U11403, U11502, U11503, U11602, U11603: UCC27524DR; SOIC-8_3.9x4.9mm_P1.27mm; LCSC C465729

Connections of its further copies:
+5V: C10101.1, C10201.1, C10301.1, C10401.1, C10501.1, C10601.1, C10701.1, C10801.1, C10901.1, C11001.1, C11101.1, C11201.1, C11301.1, C11401.1, C11501.1, C11601.1, U10101.16 (VCC), U10201.16 (VCC), U10301.16 (VCC), U10401.16 (VCC), U10501.16 (VCC), U10601.16 (VCC), U10701.16 (VCC), U10801.16 (VCC), U10901.16 (VCC), U11001.16 (VCC), U11101.16 (VCC), U11201.16 (VCC), U11301.16 (VCC), U11401.16 (VCC), U11501.16 (VCC), U11601.16 (VCC); also elsewhere on the board
DRV1: U10102.5 (OUTB); also elsewhere on the board
DRV2: U10102.7 (OUTA); also elsewhere on the board
DRV3: U10103.5 (OUTB); also elsewhere on the board
DRV4: U10103.7 (OUTA); also elsewhere on the board
DRV5: U10202.5 (OUTB); also elsewhere on the board
DRV6: U10202.7 (OUTA); also elsewhere on the board
DRV7: U10203.5 (OUTB); also elsewhere on the board
DRV8: U10203.7 (OUTA); also elsewhere on the board
DRV9: U10302.5 (OUTB); also elsewhere on the board
DRV10: U10302.7 (OUTA); also elsewhere on the board
DRV11: U10303.5 (OUTB); also elsewhere on the board
DRV12: U10303.7 (OUTA); also elsewhere on the board
DRV13: U10402.5 (OUTB); also elsewhere on the board
DRV14: U10402.7 (OUTA); also elsewhere on the board
DRV15: U10403.5 (OUTB); also elsewhere on the board
DRV16: U10403.7 (OUTA); also elsewhere on the board
DRV17: U10502.5 (OUTB); also elsewhere on the board
DRV18: U10502.7 (OUTA); also elsewhere on the board
DRV19: U10503.5 (OUTB); also elsewhere on the board
DRV20: U10503.7 (OUTA); also elsewhere on the board
DRV21: U10602.5 (OUTB); also elsewhere on the board
DRV22: U10602.7 (OUTA); also elsewhere on the board
DRV23: U10603.5 (OUTB); also elsewhere on the board
DRV24: U10603.7 (OUTA); also elsewhere on the board
DRV25: U10702.5 (OUTB); also elsewhere on the board
DRV26: U10702.7 (OUTA); also elsewhere on the board
DRV27: U10703.5 (OUTB); also elsewhere on the board
DRV28: U10703.7 (OUTA); also elsewhere on the board
DRV29: U10802.5 (OUTB); also elsewhere on the board
DRV30: U10802.7 (OUTA); also elsewhere on the board
DRV31: U10803.5 (OUTB); also elsewhere on the board
DRV32: U10803.7 (OUTA); also elsewhere on the board
DRV33: U10902.5 (OUTB); also elsewhere on the board
DRV34: U10902.7 (OUTA); also elsewhere on the board
DRV35: U10903.5 (OUTB); also elsewhere on the board
DRV36: U10903.7 (OUTA); also elsewhere on the board
DRV37: U11002.5 (OUTB); also elsewhere on the board
DRV38: U11002.7 (OUTA); also elsewhere on the board
DRV39: U11003.5 (OUTB); also elsewhere on the board
DRV40: U11003.7 (OUTA); also elsewhere on the board
DRV41: U11102.5 (OUTB); also elsewhere on the board
DRV42: U11102.7 (OUTA); also elsewhere on the board
DRV43: U11103.5 (OUTB); also elsewhere on the board
DRV44: U11103.7 (OUTA); also elsewhere on the board
DRV45: U11202.5 (OUTB); also elsewhere on the board
DRV46: U11202.7 (OUTA); also elsewhere on the board
DRV47: U11203.5 (OUTB); also elsewhere on the board
DRV48: U11203.7 (OUTA); also elsewhere on the board
DRV49: U11302.5 (OUTB); also elsewhere on the board
DRV50: U11302.7 (OUTA); also elsewhere on the board
DRV51: U11303.5 (OUTB); also elsewhere on the board
DRV52: U11303.7 (OUTA); also elsewhere on the board
DRV53: U11402.5 (OUTB); also elsewhere on the board
DRV54: U11402.7 (OUTA); also elsewhere on the board
DRV55: U11403.5 (OUTB); also elsewhere on the board
DRV56: U11403.7 (OUTA); also elsewhere on the board
DRV57: U11502.5 (OUTB); also elsewhere on the board
DRV58: U11502.7 (OUTA); also elsewhere on the board
DRV59: U11503.5 (OUTB); also elsewhere on the board
DRV60: U11503.7 (OUTA); also elsewhere on the board
DRV61: U11602.5 (OUTB); also elsewhere on the board
DRV62: U11602.7 (OUTA); also elsewhere on the board
DRV63: U11603.5 (OUTB); also elsewhere on the board
DRV64: U11603.7 (OUTA); also elsewhere on the board
GND: C10101.2, C10102.2, C10103.2, C10104.2, C10105.2, C10201.2, C10202.2, C10203.2, C10204.2, C10205.2, C10301.2, C10302.2, C10303.2, C10304.2, C10305.2, C10401.2, C10402.2, C10403.2, C10404.2, C10405.2, C10501.2, C10502.2, C10503.2, C10504.2, C10505.2, C10601.2, C10602.2, C10603.2, C10604.2, C10605.2, C10701.2, C10702.2, C10703.2, C10704.2, C10705.2, C10801.2, C10802.2, C10803.2, C10804.2, C10805.2, C10901.2, C10902.2, C10903.2, C10904.2, C10905.2, C11001.2, C11002.2, C11003.2, C11004.2, C11005.2, C11101.2, C11102.2, C11103.2, C11104.2, C11105.2, C11201.2, C11202.2, C11203.2, C11204.2, C11205.2, C11301.2, C11302.2, C11303.2, C11304.2, C11305.2, C11401.2, C11402.2, C11403.2, C11404.2, C11405.2, C11501.2, C11502.2, C11503.2, C11504.2, C11505.2, C11601.2, C11602.2, C11603.2, C11604.2, C11605.2, U10101.8 (GND), U10102.3 (GND), U10103.3 (GND), U10201.8 (GND), U10202.3 (GND), U10203.3 (GND), U10301.8 (GND), U10302.3 (GND), U10303.3 (GND), U10401.8 (GND), U10402.3 (GND), U10403.3 (GND), U10501.8 (GND), U10502.3 (GND), U10503.3 (GND), U10601.8 (GND), U10602.3 (GND), U10603.3 (GND), U10701.8 (GND), U10702.3 (GND), U10703.3 (GND), U10801.8 (GND), U10802.3 (GND), U10803.3 (GND), U10901.8 (GND), U10902.3 (GND), U10903.3 (GND), U11001.8 (GND), U11002.3 (GND), U11003.3 (GND), U11101.8 (GND), U11102.3 (GND), U11103.3 (GND), U11201.8 (GND), U11202.3 (GND), U11203.3 (GND), U11301.8 (GND), U11302.3 (GND), U11303.3 (GND), U11401.8 (GND), U11402.3 (GND), U11403.3 (GND), U11501.8 (GND), U11502.3 (GND), U11503.3 (GND), U11601.8 (GND), U11602.3 (GND), U11603.3 (GND); also elsewhere on the board
unnamed: U10101.15 (QA), U10102.4 (INB)
unnamed: U10101.1 (QB), U10102.2 (INA)
unnamed: U10101.2 (QC), U10103.4 (INB)
unnamed: U10101.3 (QD), U10103.2 (INA)
unnamed: U10201.15 (QA), U10202.4 (INB)
unnamed: U10201.1 (QB), U10202.2 (INA)
unnamed: U10201.2 (QC), U10203.4 (INB)
unnamed: U10201.3 (QD), U10203.2 (INA)
unnamed: U10301.15 (QA), U10302.4 (INB)
unnamed: U10301.1 (QB), U10302.2 (INA)
unnamed: U10301.2 (QC), U10303.4 (INB)
unnamed: U10301.3 (QD), U10303.2 (INA)
unnamed: U10401.15 (QA), U10402.4 (INB)
unnamed: U10401.1 (QB), U10402.2 (INA)
unnamed: U10401.2 (QC), U10403.4 (INB)
unnamed: U10401.3 (QD), U10403.2 (INA)
unnamed: U10501.15 (QA), U10502.4 (INB)
unnamed: U10501.1 (QB), U10502.2 (INA)
unnamed: U10501.2 (QC), U10503.4 (INB)
unnamed: U10501.3 (QD), U10503.2 (INA)
unnamed: U10601.15 (QA), U10602.4 (INB)
unnamed: U10601.1 (QB), U10602.2 (INA)
unnamed: U10601.2 (QC), U10603.4 (INB)
unnamed: U10601.3 (QD), U10603.2 (INA)
unnamed: U10701.15 (QA), U10702.4 (INB)
unnamed: U10701.1 (QB), U10702.2 (INA)
unnamed: U10701.2 (QC), U10703.4 (INB)
unnamed: U10701.3 (QD), U10703.2 (INA)
unnamed: U10801.15 (QA), U10802.4 (INB)
unnamed: U10801.1 (QB), U10802.2 (INA)
unnamed: U10801.2 (QC), U10803.4 (INB)
unnamed: U10801.3 (QD), U10803.2 (INA)
unnamed: U10901.15 (QA), U10902.4 (INB)
unnamed: U10901.1 (QB), U10902.2 (INA)
unnamed: U10901.2 (QC), U10903.4 (INB)
unnamed: U10901.3 (QD), U10903.2 (INA)
unnamed: U11001.15 (QA), U11002.4 (INB)
unnamed: U11001.1 (QB), U11002.2 (INA)
unnamed: U11001.2 (QC), U11003.4 (INB)
unnamed: U11001.3 (QD), U11003.2 (INA)
unnamed: U11101.15 (QA), U11102.4 (INB)
unnamed: U11101.1 (QB), U11102.2 (INA)
unnamed: U11101.2 (QC), U11103.4 (INB)
unnamed: U11101.3 (QD), U11103.2 (INA)
unnamed: U11201.15 (QA), U11202.4 (INB)
unnamed: U11201.1 (QB), U11202.2 (INA)
unnamed: U11201.2 (QC), U11203.4 (INB)
unnamed: U11201.3 (QD), U11203.2 (INA)
unnamed: U11301.15 (QA), U11302.4 (INB)
unnamed: U11301.1 (QB), U11302.2 (INA)
unnamed: U11301.2 (QC), U11303.4 (INB)
unnamed: U11301.3 (QD), U11303.2 (INA)
unnamed: U11401.15 (QA), U11402.4 (INB)
unnamed: U11401.1 (QB), U11402.2 (INA)
unnamed: U11401.2 (QC), U11403.4 (INB)
unnamed: U11401.3 (QD), U11403.2 (INA)
unnamed: U11501.15 (QA), U11502.4 (INB)
unnamed: U11501.1 (QB), U11502.2 (INA)
unnamed: U11501.2 (QC), U11503.4 (INB)
unnamed: U11501.3 (QD), U11503.2 (INA)
unnamed: U11601.15 (QA), U11602.4 (INB)
unnamed: U11601.1 (QB), U11602.2 (INA)
unnamed: U11601.2 (QC), U11603.4 (INB)
unnamed: U11601.3 (QD), U11603.2 (INA)
TX_CLR_N: U10101.10 (~SRCLR), U10201.10 (~SRCLR), U10301.10 (~SRCLR), U10401.10 (~SRCLR), U10501.10 (~SRCLR), U10601.10 (~SRCLR), U10701.10 (~SRCLR), U10801.10 (~SRCLR), U10901.10 (~SRCLR), U11001.10 (~SRCLR), U11101.10 (~SRCLR), U11201.10 (~SRCLR), U11301.10 (~SRCLR), U11401.10 (~SRCLR), U11501.10 (~SRCLR), U11601.10 (~SRCLR); also elsewhere on the board
TX_EN1: U10102.1 (ENA), U10102.8 (ENB), U10103.1 (ENA), U10103.8 (ENB), U10202.1 (ENA), U10202.8 (ENB), U10203.1 (ENA), U10203.8 (ENB), U10302.1 (ENA), U10302.8 (ENB), U10303.1 (ENA), U10303.8 (ENB), U10402.1 (ENA), U10402.8 (ENB), U10403.1 (ENA), U10403.8 (ENB); also elsewhere on the board
TX_EN2: U10502.1 (ENA), U10502.8 (ENB), U10503.1 (ENA), U10503.8 (ENB), U10602.1 (ENA), U10602.8 (ENB), U10603.1 (ENA), U10603.8 (ENB), U10702.1 (ENA), U10702.8 (ENB), U10703.1 (ENA), U10703.8 (ENB), U10802.1 (ENA), U10802.8 (ENB), U10803.1 (ENA), U10803.8 (ENB); also elsewhere on the board
TX_EN3: U10902.1 (ENA), U10902.8 (ENB), U10903.1 (ENA), U10903.8 (ENB), U11002.1 (ENA), U11002.8 (ENB), U11003.1 (ENA), U11003.8 (ENB), U11102.1 (ENA), U11102.8 (ENB), U11103.1 (ENA), U11103.8 (ENB), U11202.1 (ENA), U11202.8 (ENB), U11203.1 (ENA), U11203.8 (ENB); also elsewhere on the board
TX_EN4: U11302.1 (ENA), U11302.8 (ENB), U11303.1 (ENA), U11303.8 (ENB), U11402.1 (ENA), U11402.8 (ENB), U11403.1 (ENA), U11403.8 (ENB), U11502.1 (ENA), U11502.8 (ENB), U11503.1 (ENA), U11503.8 (ENB), U11602.1 (ENA), U11602.8 (ENB), U11603.1 (ENA), U11603.8 (ENB); also elsewhere on the board
TX_LATCH_A: U10101.12 (RCLK), U10201.12 (RCLK), U10301.12 (RCLK), U10401.12 (RCLK); also elsewhere on the board
TX_LATCH_B: U10501.12 (RCLK), U10601.12 (RCLK), U10701.12 (RCLK), U10801.12 (RCLK); also elsewhere on the board
TX_LATCH_C: U10901.12 (RCLK), U11001.12 (RCLK), U11101.12 (RCLK), U11201.12 (RCLK); also elsewhere on the board
TX_LATCH_D: U11301.12 (RCLK), U11401.12 (RCLK), U11501.12 (RCLK), U11601.12 (RCLK); also elsewhere on the board
TX_OE_N: U10101.13 (~OE), U10201.13 (~OE), U10301.13 (~OE), U10401.13 (~OE), U10501.13 (~OE), U10601.13 (~OE), U10701.13 (~OE), U10801.13 (~OE), U10901.13 (~OE), U11001.13 (~OE), U11101.13 (~OE), U11201.13 (~OE), U11301.13 (~OE), U11401.13 (~OE), U11501.13 (~OE), U11601.13 (~OE); also elsewhere on the board
TX_SCK_A: U10101.11 (SRCLK), U10201.11 (SRCLK), U10301.11 (SRCLK), U10401.11 (SRCLK); also elsewhere on the board
TX_SCK_B: U10501.11 (SRCLK), U10601.11 (SRCLK), U10701.11 (SRCLK), U10801.11 (SRCLK); also elsewhere on the board
TX_SCK_C: U10901.11 (SRCLK), U11001.11 (SRCLK), U11101.11 (SRCLK), U11201.11 (SRCLK); also elsewhere on the board
TX_SCK_D: U11301.11 (SRCLK), U11401.11 (SRCLK), U11501.11 (SRCLK), U11601.11 (SRCLK); also elsewhere on the board
TX_SDI0: U10101.14 (SER); also elsewhere on the board
TX_SDI1: U10201.14 (SER); also elsewhere on the board
TX_SDI2: U10301.14 (SER); also elsewhere on the board
TX_SDI3: U10401.14 (SER); also elsewhere on the board
TX_SDI4: U10501.14 (SER); also elsewhere on the board
TX_SDI5: U10601.14 (SER); also elsewhere on the board
TX_SDI6: U10701.14 (SER); also elsewhere on the board
TX_SDI7: U10801.14 (SER); also elsewhere on the board
TX_SDI8: U10901.14 (SER); also elsewhere on the board
TX_SDI9: U11001.14 (SER); also elsewhere on the board
TX_SDI10: U11101.14 (SER); also elsewhere on the board
TX_SDI11: U11201.14 (SER); also elsewhere on the board
TX_SDI12: U11301.14 (SER); also elsewhere on the board
TX_SDI13: U11401.14 (SER); also elsewhere on the board
TX_SDI14: U11501.14 (SER); also elsewhere on the board
TX_SDI15: U11601.14 (SER); also elsewhere on the board
VDRV: C10102.1, C10103.1, C10104.1, C10105.1, C10202.1, C10203.1, C10204.1, C10205.1, C10302.1, C10303.1, C10304.1, C10305.1, C10402.1, C10403.1, C10404.1, C10405.1, C10502.1, C10503.1, C10504.1, C10505.1, C10602.1, C10603.1, C10604.1, C10605.1, C10702.1, C10703.1, C10704.1, C10705.1, C10802.1, C10803.1, C10804.1, C10805.1, C10902.1, C10903.1, C10904.1, C10905.1, C11002.1, C11003.1, C11004.1, C11005.1, C11102.1, C11103.1, C11104.1, C11105.1, C11202.1, C11203.1, C11204.1, C11205.1, C11302.1, C11303.1, C11304.1, C11305.1, C11402.1, C11403.1, C11404.1, C11405.1, C11502.1, C11503.1, C11504.1, C11505.1, C11602.1, C11603.1, C11604.1, C11605.1, U10102.6 (V_{DD}), U10103.6 (V_{DD}), U10202.6 (V_{DD}), U10203.6 (V_{DD}), U10302.6 (V_{DD}), U10303.6 (V_{DD}), U10402.6 (V_{DD}), U10403.6 (V_{DD}), U10502.6 (V_{DD}), U10503.6 (V_{DD}), U10602.6 (V_{DD}), U10603.6 (V_{DD}), U10702.6 (V_{DD}), U10703.6 (V_{DD}), U10802.6 (V_{DD}), U10803.6 (V_{DD}), U10902.6 (V_{DD}), U10903.6 (V_{DD}), U11002.6 (V_{DD}), U11003.6 (V_{DD}), U11102.6 (V_{DD}), U11103.6 (V_{DD}), U11202.6 (V_{DD}), U11203.6 (V_{DD}), U11302.6 (V_{DD}), U11303.6 (V_{DD}), U11402.6 (V_{DD}), U11403.6 (V_{DD}), U11502.6 (V_{DD}), U11503.6 (V_{DD}), U11602.6 (V_{DD}), U11603.6 (V_{DD}); also elsewhere on the board

Notes on the sheet:
TX group: 4 elements. 74HCT595 QA-QD -> UCC27524 inputs; QE-QH unused (16 data lines, 10 MHz SRCLK)
EN from one 74AHCT1G125 per 8 drivers (en_buf). SCK/LATCH from a clk_buf output (<= 4 loads).

Schematic: en_buf.kicad_sch, TX enable buffer (x4): 74AHCT1G125

Parts:
C1: 100n 16V X7R; C_0603_1608Metric; LCSC C14663
U1: 74AHCT1G125; SOT-23-5; LCSC C7484

Parts of its further copies:
C12101, C12201, C12301, C12401: 100n 16V X7R; C_0603_1608Metric; LCSC C14663
U12101, U12201, U12301, U12401: 74AHCT1G125; SOT-23-5; LCSC C7484

Connections of its further copies:
+5V: C12101.1, C12201.1, C12301.1, C12401.1, U12101.5 (VCC), U12201.5 (VCC), U12301.5 (VCC), U12401.5 (VCC); also elsewhere on the board
GND: C12101.2, C12201.2, C12301.2, C12401.2, U12101.1, U12101.3 (GND), U12201.1, U12201.3 (GND), U12301.1, U12301.3 (GND), U12401.1, U12401.3 (GND); also elsewhere on the board
TX_EN1: U12101.4; also elsewhere on the board
TX_EN2: U12201.4; also elsewhere on the board
TX_EN3: U12301.4; also elsewhere on the board
TX_EN4: U12401.4; also elsewhere on the board
TX_EN_FPGA: U12101.2, U12201.2, U12301.2, U12401.2; also elsewhere on the board

Notes on the sheet:
TX enable buffer: 74AHCT1G125, 3.3 V in (TTL threshold), 5 V out to 8 UCC27524 (16 EN pins)
